Properties of the parts of a building model (IFC4), part 3 of 5

# IfcCableCarrierSegment: Eletroduto tipo leve (609)
Name | In | Diâmetro interno (cm) | Diâmetro | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Rede | Eletroduto PVC flexível - Eletroduto leve - 3/4" (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - 2.5 mm² (cm)
CE64 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 1034.58 | 3/4" | Cabeamento | 1034.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 3103.74 cm
CE7 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Cabeamento | 130 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 260 cm
CE8 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 50 | 3/4" | Cabeamento | 50 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 150 cm
CE9 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 50 | 3/4" | Cabeamento | 50 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 50 cm
EL10 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 440
EL100 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 750
EL101 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 750
EL102 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 375 | 3/4" | Elétrica | 375 | 1125
EL104 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 550
EL106 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 440
EL108 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 480
EL11 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL111 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 760
EL112 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 320 | 3/4" | Elétrica | 320 | 1600
EL117 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 690
EL119 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 1840
EL120 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 275 | 3/4" | Elétrica | 275 | 1100
EL122 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 440
EL123 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 20 | 3/4" | Elétrica | 20 | 60
EL124 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 690
EL127 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 440
EL128 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 349 | 3/4" | Elétrica | 349 | 1047
EL129 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330
EL13 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 480
EL130 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330
EL132 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL134 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 650
EL136 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1200
EL138 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 920
EL140 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 1840
EL142 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 440
EL143 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL144 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 359 | 3/4" | Elétrica | 359 | 1077
EL145 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330
EL146 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330
EL148 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL15 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 220 | 3/4" | Elétrica | 220 | 660
EL150 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 650
EL152 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 450 | 3/4" | Elétrica | 450 | 1350
EL154 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 440
EL155 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 452 | 3/4" | Elétrica | 452 | 1356
EL156 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 90 | 3/4" | Elétrica | 90 | 270
EL158 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1200
EL16 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 245 | 3/4" | Elétrica | 245 | 490
EL160 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 950
EL161 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 420
EL162 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 176 | 3/4" | Elétrica | 176 | 880
EL163 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 259 | 3/4" | Elétrica | 259 | 1813
EL165 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 349 | 3/4" | Elétrica | 349 | 1047
EL166 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL168 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 170 | 3/4" | Elétrica | 170 | 850
EL170 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 1250
EL172 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 1250
EL176 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 156 | 3/4" | Elétrica | 156 | 780
EL178 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 293 | 3/4" | Elétrica | 293 | 586
EL18 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL180 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 640
EL181 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 285 | 3/4" | Elétrica | 285 | 570
EL183 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 240 | 3/4" | Elétrica | 240 | 720
EL184 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 310 | 3/4" | Elétrica | 310 | 620
EL189 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 220 | 3/4" | Elétrica | 220 | 660
EL19 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 245 | 3/4" | Elétrica | 245 | 490
EL192 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 355 | 3/4" | Elétrica | 355 | 1065
EL194 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 165 | 3/4" | Elétrica | 165 | 495
EL196 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 180 | 3/4" | Elétrica | 180 | 540
EL197 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 260 | 3/4" | Elétrica | 260 | 520
EL199 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 219 | 3/4" | Elétrica | 219 | 438
EL200 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 281 | 3/4" | Elétrica | 281 | 562
EL201 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 1050
EL204 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 400
EL206 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL208 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 950
EL209 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 289 | 3/4" | Elétrica | 289 | 867
EL21 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL211 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 304 | 3/4" | Elétrica | 304 | 912
EL213 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 300 | 3/4" | Elétrica | 300 | 1800
EL214 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 220 | 3/4" | Elétrica | 220 | 1100
EL216 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 331 | 3/4" | Elétrica | 331 | 1986
EL218 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 331 | 3/4" | Elétrica | 331 | 1986
EL221 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 950
EL225 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 300 | 3/4" | Elétrica | 300 | 1200
EL231 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 80 | 3/4" | Elétrica | 80 | 240
EL233 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 330 | 3/4" | Elétrica | 330 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 1.5 mm²: 990 cm
EL234 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 269 | 3/4" | Elétrica | 269 | 538
EL235 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 209 | 3/4" | Elétrica | 209 | 627
EL236 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 219 | 3/4" | Elétrica | 219 | 657
EL238 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 70 | 3/4" | Elétrica | 70 | 210
EL239 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 401 | 3/4" | Elétrica | 401 | 1203
EL24 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330.001
EL241 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 750
EL243 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 1050
EL244 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 409 | 3/4" | Elétrica | 409 | 1227
EL246 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 369 | 3/4" | Elétrica | 369 | 1107
EL247 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 104 | 3/4" | Elétrica | 104 | 312
EL249 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 800
EL251 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 389 | 3/4" | Elétrica | 389 | 1167
EL252 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 1120
EL254 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 1120
EL256 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 500
EL258 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 1120
EL259 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 399 | 3/4" | Elétrica | 399 | 1197
EL26 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 420.001
EL261 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 1120
EL263 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 80 | 3/4" | Elétrica | 80 | 480
EL265 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL267 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 950
EL268 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 329 | 3/4" | Elétrica | 329 | 987
EL270 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 329 | 3/4" | Elétrica | 329 | 987
EL274 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 325 | 3/4" | Elétrica | 325 | 975
EL276 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 335 | 3/4" | Elétrica | 335 | 1005
EL277 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 60 | 3/4" | Elétrica | 60 | 180
EL278 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 80 | 3/4" | Elétrica | 80 | 240
EL279 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 70 | 3/4" | Elétrica | 70 | 210
EL28 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 270 | 3/4" | Elétrica | 270 | 810
EL280 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL281 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 70 | 3/4" | Elétrica | 70 | 210
EL282 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 70 | 3/4" | Elétrica | 70 | 210
EL283 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 420
EL284 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 70 | 3/4" | Elétrica | 70 | 210
EL285 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 70 | 3/4" | Elétrica | 70 | 210
EL286 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 60 | 3/4" | Elétrica | 60 | 180
EL287 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL288 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 80 | 3/4" | Elétrica | 80 | 240
EL289 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 390 | 3/4" | Elétrica (ARC) | 390 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1170 cm
EL293 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 305 | 3/4" | Elétrica (ARC) | 305 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1525 cm
EL294 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 279 | 3/4" | Elétrica (ARC) | 279 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1395 cm
EL295 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 151 | 3/4" | Elétrica (ARC) | 151 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 453 cm
EL297 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 77 | 3/4" | Elétrica (ARC) | 77 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 231 cm
EL298 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 175 | 3/4" | Elétrica (ARC) | 175 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 525 cm
EL30 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 400 | 3/4" | Elétrica | 400 | 2000
EL301 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 605 | 3/4" | Elétrica (ARC) | 605 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1815 cm
EL303 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 420 | 3/4" | Elétrica | 420 | 1260
EL304 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 239 | 3/4" | Elétrica | 239 | 478
EL305 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 389.2 | 3/4" | Elétrica | 389.2 | 1946
EL306 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 750
EL307 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 689 | 3/4" | Elétrica | 689 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 1.5 mm²: 2067 cm
EL311 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL312 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 269.6 | 3/4" | Elétrica | 269.6 | 2156.8
EL313 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 880
EL314 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 310 | 3/4" | Elétrica | 310 | 2170
EL316 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica (ARC) | 130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 390 cm
EL317 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 552 | 3/4" | Elétrica (ARC) | 552 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1656 cm
EL318 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 41 | 3/4" | Elétrica | 41 | 246
EL319 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 151 | 3/4" | Elétrica (ARC) | 151
EL32 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 285 | 3/4" | Elétrica | 285 | 570
EL33 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 415 | 3/4" | Elétrica | 415 | 1245
EL35 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 175 | 3/4" | Elétrica | 175 | 525
EL37 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450.001
EL38 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 255 | 3/4" | Elétrica | 255 | 510
EL40 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL42 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL43 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 275 | 3/4" | Elétrica | 275 | 550
EL45 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 380 | 3/4" | Elétrica | 380 | 1140
EL47 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330.001
EL50 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 354 | 3/4" | Elétrica | 354 | 1062
EL51 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 170 | 3/4" | Elétrica | 170 | 510
EL54 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 240 | 3/4" | Elétrica | 240 | 960
EL56 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 240 | 3/4" | Elétrica | 240 | 960
EL59 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL61 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450.001
EL62 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 750
EL64 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL66 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL67 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 305 | 3/4" | Elétrica | 305 | 610
EL69 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL71 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL73 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450.001
EL76 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 322 | 3/4" | Elétrica | 322 | 644
EL78 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 274 | 3/4" | Elétrica | 274 | 822
EL8 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL80 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 285 | 3/4" | Elétrica | 285 | 570
EL81 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 445 | 3/4" | Elétrica | 445 | 1335
EL83 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 480
EL85 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL87 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL89 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 600
EL91 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450.001
EL93 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 480
EL95 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 450 | 3/4" | Elétrica | 450 | 1350
EL97 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 40 | 3/4" | Elétrica | 40.0004 | 120.001
EL99 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 40 | 3/4" | Elétrica | 40.0004 | 120.001
EL11 | CAIXA D AGUA | 1.94 | ø3/4" | 0.15 | ø3/4" | 500 | 3/4" | Elétrica | 500 | 1500
EL12 | CAIXA D AGUA | 1.94 | ø3/4" | 0.15 | ø3/4" | 500 | 3/4" | Elétrica | 500 | 1500
EL13 | CAIXA D AGUA | 1.94 | ø3/4" | 0.15 | ø3/4" | 69.02 | 3/4" | Elétrica | 69.025 | 207.075
EL14 | CAIXA D AGUA | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 300
EL15 | CAIXA D AGUA | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 480
EL16 | CAIXA D AGUA | 1.94 | ø3/4" | 0.15 | ø3/4" | 80 | 3/4" | Elétrica | 80 | 160

# IfcCableCarrierSegment: Eletroduto tipo pesado (PEAD) (12)
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 100 cm
Identificação_Elemento - Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo pesado (PEAD); Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto tipo pesado (PEAD)
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 100 cm
Name | In | Diâmetro interno (cm) | Diâmetro | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Rede | Eletroduto PVC flexível - Eletroduto pesado - 1.1/4" (cm)
EL408 | Térreo | 8 | ø3" | 0.7 | ø3" | 1520 | 3" | Elétrica (QD) | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 150 mm²: 6080 cm; Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 70 mm²: 1520 cm; Eletroduto PVC flexível - Eletroduto pesado - 3": 1520 cm
EL191 | PAV 1 | 8 | ø3" | 0.7 | ø3" | 60 | 3" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 150 mm²: 240 cm; Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 70 mm²: 60 cm; Eletroduto PVC flexível - Eletroduto pesado - 3": 60 cm
EL194 | PAV 1 | 8 | ø3" | 0.7 | ø3" | 1480 | 3" | Elétrica (QD) | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 150 mm²: 5920 cm; Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 70 mm²: 1480 cm; Eletroduto PVC flexível - Eletroduto pesado - 3": 1480 cm
EL248 | PAV 1 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 353 | 1.1/4" | Elétrica (QD) | 706 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1765 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 2.5 mm²: 1765 cm
EL285 | PAV 1 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 583 | 1.1/4" | Elétrica (QD) | 583 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 2.5 mm²: 2332 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 5247 cm
EL4 | PAV 2 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 420 | 1.1/4" | Elétrica (QD) | 420 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 150 mm²: 1680 cm; Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 70 mm²: 420 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 2100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 12180 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 10 mm²: 2100 cm
EL48 | CAIXA D AGUA | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 30 | 1.1/4" | Elétrica | 60 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 120 cm
EL49 | CAIXA D AGUA | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 30 | 1.1/4" | Elétrica | 30
EL50 | CAIXA D AGUA | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 190 | 1.1/2" | Elétrica (ARC) | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 10 mm²: 1330 cm; Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 190 cm
EL51 | CAIXA D AGUA | 5 | ø2" | 0.63 | ø2" | 182.02 | 2" | Elétrica (ARC) | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 10 mm²: 2912.4 cm; Eletroduto PVC flexível - Eletroduto pesado - 2": 364.05 cm
EL52 | CAIXA D AGUA | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 420 | 1.1/4" | Elétrica (ARC) | 420 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 6 mm²: 2940 cm
EL7 | CAIXA D AGUA | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 667.72 | 1.1/4" | Elétrica (QD) | 667.725 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 3338.62 cm

# IfcCableCarrierSegment: Galvanizados à fogo (30)
Type - PredefinedType: CABLETRAYSEGMENT
AltoQi_Builder - Altura: 3.8 cm; Base: 3.8 cm; Comprimento máximo: 600 cm; Espessura: 0.15 cm; Indicação: #38x38
Identificação_Elemento - Nome: 38x38mm; Classe: Perfilados lisos; Tipo: Galvanizados à fogo; Rede: Cabeamento; Aplicação: Retangular aberto
Pset_CableCarrierSegmentTypeCommon - Reference: Galvanizados à fogo
Pset_CableCarrierSegmentTypeCableTraySegment - NominalHeight: 3.8 cm; NominalWidth: 3.8 cm
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 600 cm
AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S8: 1
Name | In | Comprimento (cm) = Perfilados lisos - Galvanizados à fogo - 38x38mm (cm) | Acessórios uso geral - Arruela de pressão galvan. - 1/4" = Acessórios uso geral - Arruela lisa galvan. - 1/4" = Acessórios uso geral - Parafuso galvan. cab. sext. - 1/4"x1.3/4" rosca soberba = Acessórios uso geral - Porca sextavada galvan. - 1/4" = Acessórios uso geral - Vergalhão galvan. rosca total - 1/4"x - comp. p/ proj. = Perfilados lisos - Gancho curto para perfilado - 44x32mm
CE19 | Térreo | 600 | 6 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 6000 cm
CE19 | Térreo | 410 | 5 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 6560 cm
CE19 | Térreo | 20 | 1
CE19 | Térreo | 190 | 2 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 2090 cm
CE19 | Térreo | 220 | 3 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 3300 cm
CE20 | Térreo | 1060 | 11 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 4240 cm; Perfilados lisos - Tala reta perfurada - 38mm: 1
CE20 | Térreo | 510 | 6 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 3060 cm
CE20 | Térreo | 30 | 1
CE20 | Térreo | 1060 | 11 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 10600 cm; Perfilados lisos - Tala reta perfurada - 38mm: 1
CE5 | PAV 1 | 280 | 3 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 1400 cm
CE5 | PAV 1 | 2200 | 22 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 17600 cm; Perfilados lisos - Tala reta perfurada - 38mm: 3
CE5 | PAV 1 | 20 | 1
CE5 | PAV 1 | 200 | 2 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 600 cm
CE22 | PAV 2 | 560 | 6 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 1120 cm
CE23 | PAV 2 | 10 | 1
CE36 | PAV 2 | 210 | 3 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 840 cm
CE44 | PAV 2 | 10 | 1
CE45 | PAV 2 | 260 | 3 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 7540 cm
CE46 | PAV 2 | 470 | 5 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 13630 cm
CE47 | PAV 2 | 490 | 5 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 11760 cm
CE48 | PAV 2 | 430 | 5 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 7740 cm
CE49 | PAV 2 | 400 | 4 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 8800 cm
CE50 | PAV 2 | 230 | 3 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 2990 cm
CE51 | PAV 2 | 310 | 4 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 3410 cm
CE52 | PAV 2 | 170 | 2 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 1530 cm
CE53 | PAV 2 | 50 | 1
CE54 | PAV 2 | 20 | 1
CE55 | PAV 2 | 360 | 4 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 360 cm
CE56 | PAV 2 | 770 | 8 | AltoQi_QiBuilder-Itens_Associados - Perfilados lisos - Tala reta perfurada - 38mm: 1; Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 3080 cm
CE60 | PAV 2 | 430 | 5 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 6020 cm

# IfcCableSegment: Cabo de cobre nú (Arredondado maciço) (13)
Type - PredefinedType: CONDUCTORSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm; Indicação: 35mm²; Seção (mm²): 35
Identificação_Elemento - Nome: 35mm²; Classe: SPDA - Condutos; Tipo: Cabo de cobre nú (Arredondado maciço); Rede: SPDA; Aplicação: Cordoalha
Pset_CableSegmentTypeCommon - Reference: Cabo de cobre nú (Arredondado maciço)
Pset_CableSegmentTypeConductorSegment - CrossSectionalArea: 0 m2
Name | In | Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 35mm² (cm)
2 x  | Térreo | 360
2 x  | PAV 1 | 315
2 x  | PAV 2 | 303
 | CAIXA D AGUA | 319.078
 | CAIXA D AGUA | 245
 | CAIXA D AGUA | 308.258
 | CAIXA D AGUA | 326.662
 | CAIXA D AGUA | 679.603
 | CAIXA D AGUA | 695.283
 | CAIXA D AGUA | 6.96209

# IfcCableSegment: Cabo de cobre nú (Encordoado) (36)
Type - PredefinedType: CONDUCTORSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm
Identificação_Elemento - Classe: SPDA - Condutos; Tipo: Cabo de cobre nú (Encordoado); Rede: SPDA; Aplicação: Cordoalha
Pset_CableSegmentTypeCommon - Reference: Cabo de cobre nú (Encordoado)
Pset_CableSegmentTypeConductorSegment - CrossSectionalArea: 0 m2
Name | In | Indicação = Nome | Seção (mm²) | Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 50mm² (cm)
 | Térreo | 50mm² | 50 | 1053.48
 | Térreo | 50mm² | 50 | 65.4077
 | Térreo | 50mm² | 50 | 30.3943
2 x  | Térreo | 50mm² | 50 | 1401.07
 | Térreo | 50mm² | 50 | 1117.89
 | Térreo | 50mm² | 50 | 591.753
 | Térreo | 50mm² | 50 | 798.732
 | Térreo | 50mm² | 50 | 278.976
 | Térreo | 50mm² | 50 | 250.765
4 x  | Térreo | 50mm² | 50 | 300
 | Térreo | 50mm² | 50 | 640.885
2 x  | Térreo | 50mm² | 50 | 307.377
2 x  | Térreo | 50mm² | 50 | 170.9
2 x  | Térreo | 50mm² | 50 | 443.385
 | Térreo | 50mm² | 50 | 720.884
2 x  | Térreo | 50mm² | 50 | 31.5926
 | Térreo | 50mm² | 50 | 24.6722
 | Térreo | 50mm² | 50 | 1082.97
 | Térreo | 50mm² | 50 | 26.5348
 | Térreo | 50mm² | 50 | 675.527
 | Térreo | 50mm² | 50 | 42.8752
 | Térreo | 50mm² | 50 | 35.2995
 | Térreo | 50mm² | 50 | 367.522
 | Térreo | 50mm² | 50 | 31.1894
 | Térreo | 50mm² | 50 | 112.746
 | CAIXA D AGUA | 50mm² | 50 | 63.1799
 | CAIXA D AGUA | 35mm² | 35 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 35mm²: 610.78 cm
 | CAIXA D AGUA | 35mm² | 35 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 35mm²: 238.959 cm

# IfcCableSegment: Cabo de cobre nú (c/isol. simples -Fix. horizontal - 100 mm) (Arredondado maciço) (12)
Type - PredefinedType: CONDUCTORSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm; Indicação: 35mm²; Seção (mm²): 35
Identificação_Elemento - Nome: 35mm²; Classe: SPDA - Condutos; Tipo: Cabo de cobre nú (c/isol. simples -Fix. horizontal - 100 mm) (Arredondado maciço); Rede: SPDA; Aplicação: Cordoalha
Pset_CableSegmentTypeCommon - Reference: Cabo de cobre nú (c/isol. simples -Fix. horizontal - 100 mm) (Arredondado maciço)
Pset_CableSegmentTypeConductorSegment - CrossSectionalArea: 0 m2
Name | In | Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 35mm² (cm) | Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 100 mm
 | Térreo | 120
 | Térreo | 190
2 x  | Térreo | 260
4 x  | PAV 1 | 315 | 1
4 x  | PAV 2 | 303 | 1

# IfcCableSegment: Cabo de cobre nú (c/isol. simples -Fix. horizontal - 200 mm) (Arredondado maciço) (131)
In: CAIXA D AGUA
Type - PredefinedType: CONDUCTORSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm; Indicação: 35mm²; Seção (mm²): 35
Identificação_Elemento - Nome: 35mm²; Classe: SPDA - Condutos; Tipo: Cabo de cobre nú (c/isol. simples -Fix. horizontal - 200 mm) (Arredondado maciço); Rede: SPDA; Aplicação: Cordoalha
Pset_CableSegmentTypeCommon - Reference: Cabo de cobre nú (c/isol. simples -Fix. horizontal - 200 mm) (Arredondado maciço)
Pset_CableSegmentTypeConductorSegment - CrossSectionalArea: 0 m2
Name | Condutores de proteção - SPDA - Cabo de cobre Nú - 7 fios - 35mm² (cm)
 | 31.9697
3 x  | 20
2 x  | 90
 | 193.729
 | 183.59
 | 499.238 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 23
 | 342.275 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 464.216 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 694.139 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 2
 | 627.441 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 2
2 x  | 685.289 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 2
 | 444.144 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
6 x  | 499.553 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
7 x  | 100
3 x  | 133.397
2 x  | 55.6134
3 x  | 132.975
 | 37.7405
 | 267
 | 380.938 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 42.7387
 | 27.3399
 | 347.396 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 18.6473
 | 38.0023
 | 30
 | 270
 | 341.233 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 37.8693
 | 605.992 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 2
 | 314.812 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 464.064 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 13.3692
 | 28
 | 183
 | 274.399
 | 130
 | 791.024 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 2
 | 19.1725
 | 260
 | 562.354 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 31.8895
 | 230
2 x  | 355 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 317.637 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 67.6413
 | 338.107 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 115.609
2 x  | 33.5661
 | 121.785
 | 23.8245
 | 531.705 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
2 x  | 21.3893
2 x  | 306.295 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
2 x  | 305 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 324.411 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 292.838
2 x  | 35.2216
 | 250.231
 | 36.448
 | 591.871 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 5.81981
 | 595.095 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 25.4311
 | 560.547 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 57.3935
 | 628.158 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 2
 | 336.144 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 55.1895
 | 59.0574
 | 492.58 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 39.6876
 | 64.9303
 | 197.782
 | 440.11 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 12.4141
 | 52.6219
 | 30.6031
 | 325.119 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 29.2243
 | 54.9842
2 x  | 300
 | 240
 | 250
 | 442.14 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 371.605 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 243.149
 | 86.5704
2 x  | 500.256 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 313.684 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 43.4068
 | 320.056 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1
 | 201.384
 | 609.846 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 2
 | 45.6447
 | 38.9313
3 x  | 85
 | 23.7856
 | 181.686
 | 471.564 | AltoQi_QiBuilder-Itens_Associados - Condutores de proteção - SPDA - Isolador simples - Fix. horizontal - 200 mm: 1

# IfcCableSegment: Re-bar redonda aço galvanizado (Arredondado maciço) (30)
Type - PredefinedType: CONDUCTORSEGMENT
AltoQi_Builder - Indicação: 50mm²; Seção (mm²): 50
Identificação_Elemento - Classe: SPDA - Condutos; Tipo: Re-bar redonda aço galvanizado (Arredondado maciço); Rede: SPDA; Aplicação: Cordoalha
Pset_CableSegmentTypeCommon - Reference: Re-bar redonda aço galvanizado (Arredondado maciço)
Pset_CableSegmentTypeConductorSegment - CrossSectionalArea: 0 m2
Name | In | Comprimento máximo (cm) | Nome | Condutores de proteção - SPDA - Re-bar redonda aço galvanizado - 50mm² (cm)
2 x  | Térreo | 300 | Re-bar ø8mm x 3,00m (50mm²) | 120
 | Térreo | 300 | Re-bar ø8mm x 3,00m (50mm²) | 260
 | Térreo | 300 | Re-bar ø8mm x 3,00m (50mm²) | 360.002
 | Térreo | 400 | Re-bar ø8mm x 4,00m (50mm²) | 390
 | Térreo | 400 | Re-bar ø8mm x 4,00m (50mm²) | 114.89
 | Térreo | 300 | Re-bar ø8mm x 3,00m (50mm²) | 360
5 x  | PAV 1 | 300 | Re-bar ø8mm x 3,00m (50mm²) | 315
 | PAV 1 | 400 | Re-bar ø8mm x 4,00m (50mm²) | 315
5 x  | PAV 2 | 300 | Re-bar ø8mm x 3,00m (50mm²) | 303
 | PAV 2 | 400 | Re-bar ø8mm x 4,00m (50mm²) | 303
 | CAIXA D AGUA | 300 | Re-bar ø8mm x 3,00m (50mm²) | 120
 | CAIXA D AGUA | 300 | Re-bar ø8mm x 3,00m (50mm²) | 50
2 x  | CAIXA D AGUA | 300 | Re-bar ø8mm x 3,00m (50mm²) | 300
 | CAIXA D AGUA | 300 | Re-bar ø8mm x 3,00m (50mm²) | 160
 | CAIXA D AGUA | 300 | Re-bar ø8mm x 3,00m (50mm²) | 383
 | CAIXA D AGUA | 300 | Re-bar ø8mm x 3,00m (50mm²) | 213
 | CAIXA D AGUA | 300 | 50mm² | 10.7895
 | CAIXA D AGUA | 300 | 50mm² | 330
 | CAIXA D AGUA | 400 | Re-bar ø8mm x 4,00m (50mm²) | 330
 | CAIXA D AGUA | 400 | Re-bar ø8mm x 4,00m (50mm²) | 353

# IfcElectricDistributionBoard: Barr. trif., disj geral, compacto - DIN (64)
Type - PredefinedType: DISTRIBUTIONBOARD
Name | In
7 x QD - B | Térreo
QD - B | Térreo | AltoQi_Builder - Número de polos: 12; Padrão das proteções: DIN; Comprimento: 33 cm; Largura: 9 cm; Profundidade: 43 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: QD - TER 1; Tensão: 380/220 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 275 V - 80 kA; DPS - Quantidade: 4; Proteção de Manutenção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção de Manutenção - Peça: 16 A - 4.5 kA - C; Proteção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção - Peça: 16 A - 4.5 kA - C; Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - embutir a 1,50m do piso; Nome: Cap. 12 disj. unip. - In barr. 100 A - HV; Classe: Quadro distrib. chapa pintada - embutir; Tipo: Barr. trif., disj geral, compacto - DIN; Rede: Elétrica; Pset_ElectricDistributionBoardTypeCommon - Reference: Barr. trif., disj geral, compacto - DIN; Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 16 A; NumberOfPoles: 3; Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 16 A - 4.5 kA: 2; Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 80 KA: 4; Quadro distrib. chapa pintada - embutir - Barr. trif., disj geral, compacto - DIN - Cap. 24 disj. unip. - In barr. 100 A: 1
QD - TER 1 | Térreo | AltoQi_Builder - Número de polos: 30; Padrão das proteções: DIN; Comprimento: 36 cm; Largura: 9 cm; Profundidade: 57.25 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: QGBT (CAIXA D AGUA); Tensão: 380/220 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 275 V - 80 kA; DPS - Quantidade: 4; Proteção de Manutenção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção de Manutenção - Peça: 40 A - 4.5 kA - C; Proteção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção - Peça: 40 A - 4.5 kA - C; Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - embutir a 1,50m do piso; Nome: Cap. 30 disj. unip. - In barr. 100 A - HV; Classe: Quadro distrib. chapa pintada - embutir; Tipo: Barr. trif., disj geral, compacto - DIN; Rede: Elétrica (QD); Pset_ElectricDistributionBoardTypeCommon - Reference: Barr. trif., disj geral, compacto - DIN; Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 40 A; NumberOfPoles: 3; Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 16 A - 4.5 kA: 1; Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 80 KA: 4; Quadro distrib. chapa pintada - embutir - Barr. trif., disj geral, compacto - DIN - Cap. 24 disj. unip. - In barr. 100 A: 1; Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 16 A - 3 kA: 13; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 40 A - 4.5 kA: 1
20 x QD - TER 1 | Térreo
10 x QD - PAV 1 | PAV 1
QD - PAV 1 | PAV 1 | AltoQi_Builder - Número de polos: 18; Padrão das proteções: DIN; Comprimento: 33 cm; Largura: 9 cm; Profundidade: 43 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: QGBT (CAIXA D AGUA); Tensão: 380/220 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 275 V - 80 kA; DPS - Quantidade: 4; Proteção de Manutenção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção de Manutenção - Peça: 20 A - 4.5 kA - C; Proteção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção - Peça: 20 A - 4.5 kA - C; Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - embutir a 1,50m do piso; Nome: Cap. 18 disj. unip. - In barr. 100 A - HV; Classe: Quadro distrib. chapa pintada - embutir; Tipo: Barr. trif., disj geral, compacto - DIN; Rede: Elétrica (QD); Pset_ElectricDistributionBoardTypeCommon - Reference: Barr. trif., disj geral, compacto - DIN; Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 20 A; NumberOfPoles: 3; Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 80 KA: 4; Quadro distrib. chapa pintada - embutir - Barr. trif., disj geral, compacto - DIN - Cap. 24 disj. unip. - In barr. 100 A: 1; Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 16 A - 3 kA: 4; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 20 A - 4.5 kA: 1
QD - PAV 2 | PAV 2 | AltoQi_Builder - Número de polos: 24; Padrão das proteções: DIN; Comprimento: 36 cm; Largura: 9 cm; Profundidade: 57.25 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: QGBT (CAIXA D AGUA); Tensão: 380/220 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 275 V - 80 kA; DPS - Quantidade: 4; Proteção de Manutenção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção de Manutenção - Peça: 25 A - 4.5 kA - C; Proteção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção - Peça: 25 A - 4.5 kA - C; Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - embutir a 1,50m do piso; Nome: Cap. 24 disj. unip. - In barr. 100 A - HV; Classe: Quadro distrib. chapa pintada - embutir; Tipo: Barr. trif., disj geral, compacto - DIN; Rede: Elétrica; Pset_ElectricDistributionBoardTypeCommon - Reference: Barr. trif., disj geral, compacto - DIN; Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 25 A; NumberOfPoles: 3; Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 80 KA: 4; Quadro distrib. chapa pintada - embutir - Barr. trif., disj geral, compacto - DIN - Cap. 24 disj. unip. - In barr. 100 A: 1; Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 16 A - 3 kA: 10; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 25 A - 4.5 kA: 1
16 x QD - PAV 2 | PAV 2
6 x QD - ELE1 | CAIXA D AGUA
QD - ELE1 | CAIXA D AGUA | AltoQi_Builder - Número de polos: 12; Padrão das proteções: DIN; Comprimento: 33 cm; Largura: 9 cm; Profundidade: 43 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: QGBT; Tensão: 380/220 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 275 V - 80 kA; DPS - Quantidade: 4; Proteção de Manutenção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção de Manutenção - Peça: 32 A - 4.5 kA - C; Proteção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção - Peça: 32 A - 4.5 kA - C; Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - embutir a 1,50m do piso; Nome: Cap. 12 disj. unip. - In barr. 100 A - HV; Classe: Quadro distrib. chapa pintada - embutir; Tipo: Barr. trif., disj geral, compacto - DIN; Rede: Elétrica (QD); Pset_ElectricDistributionBoardTypeCommon - Reference: Barr. trif., disj geral, compacto - DIN; Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 32 A; NumberOfPoles: 3; Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 16 A - 4.5 kA: 1; Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 80 KA: 4; Quadro distrib. chapa pintada - embutir - Barr. trif., disj geral, compacto - DIN - Cap. 24 disj. unip. - In barr. 100 A: 1; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 32 A - 4.5 kA: 1

# IfcElectricDistributionBoard: Barr. trif., disj. geral, - DIN (12)
In: CAIXA D AGUA
Type - PredefinedType: DISTRIBUTIONBOARD
Name
11 x QGBT
QGBT | AltoQi_Builder - Número de polos: 32; Padrão das proteções: DIN; Comprimento: 46.4 cm; Largura: 10.2 cm; Profundidade: 64.6 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: QM1 (Térreo); Tensão: 380/220 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 275 V - 80 kA; DPS - Quantidade: 4; Proteção de Manutenção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção de Manutenção - Peça: 350 A - 18 kA - C; Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - sobrepor a 1,50m do piso; Nome: Cap. 32 disj. unip. - In barr. 150 A; Classe: Quadro distrib. chapa pintada - sobrepor; Tipo: Barr. trif., disj. geral, - DIN; Rede: Elétrica; Pset_ElectricDistributionBoardTypeCommon - Reference: Barr. trif., disj. geral, - DIN; Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 350 A; NumberOfPoles: 3; Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 1; AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Arruela de pressão galvan. - 1/4": 4; Acessórios uso geral - Bucha de nylon - S6: 4; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 4,8x45mm autoatarrachante: 4; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 20 A - 4.5 kA: 1; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 25 A - 4.5 kA: 1; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 250 A - 18 kA: 1; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 32 A - 4.5 kA: 3; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 350 A - 18 kA: 1; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 40 A - 4.5 kA: 1; Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 80 KA: 4; Quadro distrib. chapa pintada - sobrepor - Barr. trif., disj. geral, - DIN - Cap. 32 disj. unip. - In barr. 150 A: 1

# IfcElectricDistributionBoard: Barr. trif., disj. geral, compacto - DIN (6)
In: CAIXA D AGUA
Type - PredefinedType: DISTRIBUTIONBOARD
Name
QD - ARC - 1
QD - ARC - 1 | AltoQi_Builder - Número de polos: 24; Padrão das proteções: DIN; Comprimento: 37 cm; Largura: 9 cm; Profundidade: 42 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: QGBT; Tensão: 380/220 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 275 V - 80 kA; DPS - Quantidade: 4; Proteção de Manutenção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção de Manutenção - Peça: 32 A - 4.5 kA - C; Proteção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção - Peça: 32 A - 4.5 kA - C; Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - sobrepor a 1,50m do piso; Nome: Cap. 24 disj. unip. - In barr. 100 A; Classe: Quadro distrib. chapa pintada - sobrepor; Tipo: Barr. trif., disj. geral, compacto - DIN; Rede: Elétrica (ARC); Pset_ElectricDistributionBoardTypeCommon - Reference: Barr. trif., disj. geral, compacto - DIN; Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 32 A; NumberOfPoles: 3; Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 1; AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Arruela de pressão galvan. - 1/4": 4; Acessórios uso geral - Bucha de nylon - S6: 4; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 4,8x45mm autoatarrachante: 4; Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 20 A - 3 kA: 14; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 32 A - 4.5 kA: 1; Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 80 KA: 4; Quadro distrib. chapa pintada - sobrepor - Barr. trif., disj. geral, compacto - DIN - Cap. 24 disj. unip. - In barr. 100 A: 1
QD - ARC - 2
QD - ARC - 2 | AltoQi_Builder - Número de polos: 42; Padrão das proteções: DIN; Comprimento: 42 cm; Largura: 9.5 cm; Profundidade: 56 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: QGBT; Tensão: 380/220 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 275 V - 80 kA; DPS - Quantidade: 4; Proteção de Manutenção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção de Manutenção - Peça: 250 A - 18 kA - C; Proteção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção - Peça: 250 A - 18 kA - C; Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - sobrepor a 1,50m do piso; Nome: Cap. 42 disj. unip. - In barr. 100 A; Classe: Quadro distrib. chapa pintada - sobrepor; Tipo: Barr. trif., disj. geral, compacto - DIN; Rede: Elétrica (ARC); Pset_ElectricDistributionBoardTypeCommon - Reference: Barr. trif., disj. geral, compacto - DIN; Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 250 A; NumberOfPoles: 3; Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 1; AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Arruela de pressão galvan. - 1/4": 4; Acessórios uso geral - Bucha de nylon - S6: 4; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 4,8x45mm autoatarrachante: 4; Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 80 KA: 4; Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 16 A - 3 kA: 10; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 16 A - 4.5 kA: 2; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 250 A - 18 kA: 1; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 40 A - 4.5 kA: 5; Quadro distrib. chapa pintada - sobrepor - Barr. trif., disj. geral, compacto - DIN - Cap. 42 disj. unip. - In barr. 100 A: 1
QD - B1
QD - B1 | AltoQi_Builder - Número de polos: 18; Padrão das proteções: DIN; Comprimento: 32 cm; Largura: 9 cm; Profundidade: 42 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: QGBT; Tensão: 380/220 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 275 V - 80 kA; DPS - Quantidade: 4; Proteção de Manutenção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção de Manutenção - Peça: 32 A - 4.5 kA - C; Proteção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção - Peça: 32 A - 4.5 kA - C; Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - sobrepor a 1,50m do piso; Nome: Cap. 18 disj. unip. - In barr. 100 A; Classe: Quadro distrib. chapa pintada - sobrepor; Tipo: Barr. trif., disj. geral, compacto - DIN; Rede: Elétrica; Pset_ElectricDistributionBoardTypeCommon - Reference: Barr. trif., disj. geral, compacto - DIN; Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 32 A; NumberOfPoles: 3; Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 1; AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Arruela de pressão galvan. - 1/4": 4; Acessórios uso geral - Bucha de nylon - S6: 4; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 4,8x45mm autoatarrachante: 4; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 32 A - 4.5 kA: 1; Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 80 KA: 4; Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 16 A - 3 kA: 2; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 20 A - 4.5 kA: 2; Quadro distrib. chapa pintada - sobrepor - Barr. trif., disj. geral, compacto - DIN - Cap. 18 disj. unip. - In barr. 100 A: 1

# IfcElectricDistributionBoard: Caixa de medição, QM1
In: Térreo
Type - PredefinedType: CONSUMERUNIT
AltoQi_Builder - Comprimento: 28 cm; Largura: 21.5 cm; Profundidade: 39 cm; Indicação: Des.2; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: AL1; Tensão: 380/220 V; DPS - Grupo: Nenhum; DPS - Peça: Nenhuma; DPS - Quantidade: 4; Proteção - Grupo: Disjuntor tripolar termomagnético (380 V/220 V) - DIN; Proteção - Peça: 350 A - 18 kA - C
Identificação_Elemento - Aplicação: Quadro de medição; Descrição: Caixa para medidor; Nome: Polimérica polifásica; Classe: Quadro de medição - CEMAR; Tipo: Caixa de medição; Rede: Elétrica (QD)
Pset_ElectricDistributionBoardTypeCommon - Reference: Caixa de medição
Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 350 A; NumberOfPoles: 3
AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 350 A - 18 kA: 1; Quadro de medição - CEMAR - Caixa de medição - Polimérica polifásica: 1

# IfcFlowMeter: Ramal de entrada abrigado, AL1
In: Térreo
Type - PredefinedType: ENERGYMETER
AltoQi_Builder - Comprimento: 30 cm; Largura: 10 cm; Profundidade: 30 cm; Posição: Alta; Esquema: 3F+N; Fases: R+S+T; Tensão: 380/220 V
Identificação_Elemento - Aplicação: Entrada de serviço; Descrição: Entrada de serviço subterrânea - Saída subterrânea; Nome: Eletroduto Aço 2" (TN50) - 4 fios (T3,T4); Classe: ENTRADA DE ENERGIA - EQUATORIAL PIAUÍ; Tipo: Ramal de entrada abrigado; Rede: Elétrica (QD)
Pset_FlowMeterTypeCommon - Reference: Ramal de entrada abrigado
Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 350 A; NumberOfPoles: 3
AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento

# IfcFlowSegment: Diâmetro (338)
AltoQi_Builder - Comprimento máximo: 300 cm; Diâmetro interno: 2 cm; Diâmetro: ø3/4"; Espessura: 0.06 cm
Identificação_Elemento - Nome: 3/4"; Classe: Percurso sem conduto; Tipo: Diâmetro; Rede: Elétrica; Aplicação: Circular
Pset_PipeFittingTypeCommon - Reference: Diâmetro
Name | In | Comprimento (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - 2.5 mm² (cm)
EL1 | Térreo | 20 | 60
EL1 | Térreo | 10 | 30
EL100 | Térreo | 20 | 60
EL101 | Térreo | 20 | 60
EL102 | Térreo | 20 | 60
EL103 | Térreo | 20 | 60
EL104 | Térreo | 20 | 60
EL105 | Térreo | 20 | 60
EL106 | Térreo | 20 | 60
EL108 | Térreo | 20 | 60
EL109 | Térreo | 20 | 60
EL111 | Térreo | 20 | 60
EL112 | Térreo | 20 | 60
EL113 | Térreo | 20 | 60
EL114 | Térreo | 20 | 60
EL168 | Térreo | 10 | 30
EL170 | Térreo | 20 | 60
EL172 | Térreo | 10 | 30
EL174 | Térreo | 10 | 30
EL175 | Térreo | 10 | 30
EL178 | Térreo | 10 | 20
EL179 | Térreo | 10 | 20
EL180 | Térreo | 10 | 20
EL181 | Térreo | 10 | 20
EL187 | Térreo | 10 | 30
EL188 | Térreo | 10 | 30
EL189 | Térreo | 10 | 30
EL190 | Térreo | 10 | 30
EL191 | Térreo | 10 | 30
EL192 | Térreo | 10 | 30
EL193 | Térreo | 10 | 30
EL194 | Térreo | 10 | 30
EL2 | Térreo | 10 | 30
EL2 | Térreo | 20 | 60
EL200 | Térreo | 20 | 60
EL203 | Térreo | 10 | 30
EL205 | Térreo | 10 | 30
EL206 | Térreo | 10 | 30
EL207 | Térreo | 10 | 30
EL208 | Térreo | 10 | 30
EL209 | Térreo | 10 | 30
EL210 | Térreo | 10 | 30
EL211 | Térreo | 10 | 30
EL212 | Térreo | 10 | 30
EL213 | Térreo | 10 | 30
EL214 | Térreo | 20 | 60
EL215 | Térreo | 20 | 60
EL218 | Térreo | 20 | 60
EL219 | Térreo | 20 | 60
EL220 | Térreo | 20 | 60
EL221 | Térreo | 20 | 60
EL222 | Térreo | 20 | 60
EL227 | Térreo | 20 | 60
EL228 | Térreo | 20 | 60
EL229 | Térreo | 20 | 60
EL230 | Térreo | 20 | 60
EL235 | Térreo | 20 | 60
EL245 | Térreo | 20 | 60
EL246 | Térreo | 20 | 60
EL247 | Térreo | 10 | 30
EL248 | Térreo | 10 | 30
EL249 | Térreo | 10 | 40
EL251 | Térreo | 10 | 30
EL252 | Térreo | 10 | 30
EL253 | Térreo | 10 | 30
EL254 | Térreo | 10 | 30
EL255 | Térreo | 10 | 30
EL256 | Térreo | 10 | 30
EL257 | Térreo | 10 | 30
EL258 | Térreo | 10 | 30
EL259 | Térreo | 10 | 30
EL268 | Térreo | 10 | 30
EL273 | Térreo | 20 | 60
EL274 | Térreo | 20 | 60
EL275 | Térreo | 20 | 60
EL276 | Térreo | 20 | 60
EL277 | Térreo | 20 | 60
EL278 | Térreo | 20 | 60
EL279 | Térreo | 20 | 60
EL289 | Térreo | 20 | 60
EL29 | Térreo | 20 | 60
EL290 | Térreo | 20 | 60
EL291 | Térreo | 20 | 60
EL292 | Térreo | 20 | 60
EL293 | Térreo | 20 | 60
EL294 | Térreo | 20 | 80
EL295 | Térreo | 20 | 60
EL296 | Térreo | 20 | 60
EL297 | Térreo | 20 | 60
EL298 | Térreo | 20 | 60
EL299 | Térreo | 20 | 60
EL30 | Térreo | 20 | 60
EL300 | Térreo | 20 | 60
EL301 | Térreo | 20 | 60
EL302 | Térreo | 20 | 60
EL303 | Térreo | 20 | 60
EL304 | Térreo | 20 | 60
EL305 | Térreo | 20 | 60
EL306 | Térreo | 20 | 60
EL307 | Térreo | 20 | 60
EL308 | Térreo | 20 | 60
EL309 | Térreo | 20 | 60
EL310 | Térreo | 20 | 60
EL311 | Térreo | 20 | 60
EL312 | Térreo | 20 | 60
EL32 | Térreo | 20 | 60
EL33 | Térreo | 20 | 60
EL35 | Térreo | 20 | 60
EL36 | Térreo | 20 | 60
EL368 | Térreo | 10 | 30
EL369 | Térreo | 10 | 30
EL370 | Térreo | 10 | 30
EL371 | Térreo | 290 | 870
EL372 | Térreo | 280 | 840
EL377 | Térreo | 10 | 30
EL378 | Térreo | 10 | 30
EL379 | Térreo | 10 | 30
EL380 | Térreo | 10 | 30
EL381 | Térreo | 10 | 30
EL382 | Térreo | 10 | 30
EL383 | Térreo | 10 | 30
EL384 | Térreo | 10 | 30
EL385 | Térreo | 190 | 570
EL386 | Térreo | 190 | 570
EL387 | Térreo | 100 | 300
EL393 | Térreo | 10 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 1.5 mm²: 30 cm
EL4 | Térreo | 20 | 60
EL40 | Térreo | 20 | 60
EL41 | Térreo | 20 | 60
EL428 | Térreo | 10 | 20
EL43 | Térreo | 20 | 60
EL44 | Térreo | 20 | 60
EL448 | Térreo | 10 | 30
EL46 | Térreo | 20 | 60
EL47 | Térreo | 20 | 60
EL5 | Térreo | 20 | 60
EL51 | Térreo | 20 | 60
EL516 | Térreo | 10 | 30
EL52 | Térreo | 20 | 60
EL54 | Térreo | 20 | 60
EL546 | Térreo | 10 | 30
EL549 | Térreo | 20 | 40 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 60 cm
EL55 | Térreo | 20 | 60
EL559 | Térreo | 20 | 60
EL564 | Térreo | 10 | 30
EL57 | Térreo | 20 | 60
EL58 | Térreo | 20 | 60
EL62 | Térreo | 20 | 60
EL620 | Térreo | 10 | 30
EL621 | Térreo | 10 | 30
EL622 | Térreo | 10 | 30
EL625 | Térreo | 10 | 30
EL626 | Térreo | 10 | 30
EL627 | Térreo | 10 | 30
EL63 | Térreo | 20 | 60
EL635 | Térreo | 10 | 30
EL636 | Térreo | 10 | 30
EL639 | Térreo | 10 | 30
EL642 | Térreo | 10 | 30
EL643 | Térreo | 10 | 30
EL645 | Térreo | 10 | 30
EL65 | Térreo | 20 | 60
EL66 | Térreo | 20 | 60
EL68 | Térreo | 20 | 60
EL69 | Térreo | 20 | 60
EL7 | Térreo | 20 | 60
EL73 | Térreo | 20 | 60
EL74 | Térreo | 20 | 60
EL76 | Térreo | 20 | 60
EL77 | Térreo | 20 | 60
EL79 | Térreo | 20 | 60
EL8 | Térreo | 20 | 60
EL80 | Térreo | 20 | 60
EL84 | Térreo | 20 | 60
EL85 | Térreo | 20 | 60
EL86 | Térreo | 20 | 60
EL87 | Térreo | 20 | 60
EL88 | Térreo | 20 | 60
EL89 | Térreo | 20 | 60
EL96 | Térreo | 20 | 60
EL97 | Térreo | 20 | 60
EL98 | Térreo | 20 | 60
EL99 | Térreo | 20 | 60
EL100 | PAV 1 | 10 | 30
EL101 | PAV 1 | 10 | 30
EL109 | PAV 1 | 10 | 30
EL111 | PAV 1 | 20 | 60
EL112 | PAV 1 | 20 | 60
EL113 | PAV 1 | 20 | 60
EL114 | PAV 1 | 10 | 30
EL115 | PAV 1 | 10 | 30
EL116 | PAV 1 | 10 | 30
EL117 | PAV 1 | 10 | 30
EL118 | PAV 1 | 10 | 30
EL119 | PAV 1 | 10 | 30
EL120 | PAV 1 | 10 | 30
EL121 | PAV 1 | 10 | 30
EL122 | PAV 1 | 10 | 30
EL123 | PAV 1 | 10 | 30
EL124 | PAV 1 | 10 | 30
EL125 | PAV 1 | 10 | 30
EL126 | PAV 1 | 10 | 30
EL168 | PAV 1 | 10 | 30
EL169 | PAV 1 | 10 | 30
EL170 | PAV 1 | 30 | 90
EL171 | PAV 1 | 30 | 90
EL189 | PAV 1 | 10 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 1.5 mm²: 30 cm
EL195 | PAV 1 | 10 | 30
EL196 | PAV 1 | 10 | 30
EL197 | PAV 1 | 10 | 30
EL198 | PAV 1 | 10 | 30
EL199 | PAV 1 | 10 | 30
EL200 | PAV 1 | 10 | 30
EL201 | PAV 1 | 10 | 30
EL202 | PAV 1 | 10 | 30
EL203 | PAV 1 | 20 | 60
EL204 | PAV 1 | 10 | 30
EL209 | PAV 1 | 150 | 450
EL210 | PAV 1 | 150 | 450
EL211 | PAV 1 | 150 | 450
EL212 | PAV 1 | 150 | 450
EL213 | PAV 1 | 150 | 450
EL227 | PAV 1 | 10 | 30
EL228 | PAV 1 | 10 | 30
EL253 | PAV 1 | 20 | 60
EL254 | PAV 1 | 20 | 60
EL269 | PAV 1 | 30 | 90
EL92 | PAV 1 | 20 | 60
