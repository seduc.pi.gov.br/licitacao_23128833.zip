Properties of the parts of a building model (IFC4), part 4 of 5

# IfcFlowSegment: Diâmetro (338)
Name | In | Comprimento (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - 2.5 mm² (cm)
EL93 | PAV 1 | 20 | 60
EL94 | PAV 1 | 20 | 60
EL95 | PAV 1 | 20 | 60
EL96 | PAV 1 | 10 | 30
EL97 | PAV 1 | 10 | 30
EL98 | PAV 1 | 10 | 30
EL99 | PAV 1 | 10 | 30
EL103 | PAV 2 | 10 | 30
EL105 | PAV 2 | 10 | 30
EL107 | PAV 2 | 20 | 60
EL110 | PAV 2 | 20 | 180
EL115 | PAV 2 | 20 | 60
EL116 | PAV 2 | 10 | 30
EL118 | PAV 2 | 10 | 30
EL12 | PAV 2 | 10 | 30
EL121 | PAV 2 | 20 | 60
EL126 | PAV 2 | 20 | 60
EL131 | PAV 2 | 20 | 60
EL133 | PAV 2 | 20 | 60
EL135 | PAV 2 | 20 | 60
EL137 | PAV 2 | 10 | 30
EL139 | PAV 2 | 10 | 30
EL14 | PAV 2 | 10 | 30
EL141 | PAV 2 | 20 | 60
EL147 | PAV 2 | 20 | 60
EL149 | PAV 2 | 20 | 60
EL151 | PAV 2 | 10 | 30
EL153 | PAV 2 | 20 | 60
EL157 | PAV 2 | 20 | 60
EL159 | PAV 2 | 20 | 60
EL164 | PAV 2 | 20 | 60
EL167 | PAV 2 | 10 | 30
EL169 | PAV 2 | 10 | 30
EL17 | PAV 2 | 10 | 30
EL171 | PAV 2 | 20 | 60
EL177 | PAV 2 | 10 | 30
EL179 | PAV 2 | 20 | 60
EL182 | PAV 2 | 10 | 30
EL187 | PAV 2 | 10 | 30
EL188 | PAV 2 | 10 | 30
EL190 | PAV 2 | 10 | 30
EL193 | PAV 2 | 20 | 60
EL195 | PAV 2 | 10 | 40
EL198 | PAV 2 | 20 | 60
EL20 | PAV 2 | 10 | 30
EL205 | PAV 2 | 20 | 60
EL207 | PAV 2 | 20 | 60
EL210 | PAV 2 | 20 | 60
EL212 | PAV 2 | 20 | 60
EL215 | PAV 2 | 20 | 60
EL217 | PAV 2 | 20 | 60
EL219 | PAV 2 | 20 | 60
EL22 | PAV 2 | 10 | 30
EL224 | PAV 2 | 20 | 60
EL226 | PAV 2 | 20 | 60
EL23 | PAV 2 | 20 | 60
EL230 | PAV 2 | 10 | 30
EL232 | PAV 2 | 10 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 1.5 mm²: 30 cm
EL237 | PAV 2 | 10 | 30
EL240 | PAV 2 | 20 | 60
EL242 | PAV 2 | 20 | 60
EL245 | PAV 2 | 20 | 60
EL248 | PAV 2 | 20 | 60
EL25 | PAV 2 | 20 | 60
EL250 | PAV 2 | 20 | 60
EL253 | PAV 2 | 20 | 60
EL255 | PAV 2 | 20 | 60
EL257 | PAV 2 | 20 | 60
EL260 | PAV 2 | 20 | 60
EL262 | PAV 2 | 20 | 60
EL264 | PAV 2 | 20 | 60
EL266 | PAV 2 | 20 | 60
EL269 | PAV 2 | 20 | 60
EL27 | PAV 2 | 10 | 30
EL271 | PAV 2 | 20 | 60
EL272 | PAV 2 | 10 | 30
EL273 | PAV 2 | 10 | 30
EL275 | PAV 2 | 10 | 60
EL29 | PAV 2 | 10 | 30
EL34 | PAV 2 | 10 | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
EL36 | PAV 2 | 10 | 30
EL39 | PAV 2 | 10 | 30
EL41 | PAV 2 | 10 | 30
EL44 | PAV 2 | 10 | 30
EL46 | PAV 2 | 20 | 60
EL49 | PAV 2 | 20 | 60
EL53 | PAV 2 | 10 | 30
EL55 | PAV 2 | 10 | 30
EL57 | PAV 2 | 10 | 30
EL58 | PAV 2 | 10 | 30
EL60 | PAV 2 | 10 | 30
EL63 | PAV 2 | 10 | 30
EL65 | PAV 2 | 10 | 30
EL68 | PAV 2 | 20 | 60
EL7 | PAV 2 | 10 | 30
EL70 | PAV 2 | 10 | 30
EL72 | PAV 2 | 10 | 30
EL74 | PAV 2 | 10 | 30
EL77 | PAV 2 | 10 | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
EL79 | PAV 2 | 10 | 30
EL82 | PAV 2 | 20 | 60
EL84 | PAV 2 | 10 | 30
EL86 | PAV 2 | 10 | 30
EL88 | PAV 2 | 10 | 30
EL9 | PAV 2 | 10 | 30
EL90 | PAV 2 | 10 | 30
EL92 | PAV 2 | 20 | 60
EL94 | PAV 2 | 10 | 30
EL96 | PAV 2 | 10 | 30
EL98 | PAV 2 | 10 | 30

# IfcJunctionBox: Alvenaria - piso, CX202
In: Térreo
Type - PredefinedType: POWER
AltoQi_Builder - Comprimento: 30 cm; Largura: 30 cm; Profundidade: 30 cm; Indicação: 30x30x30; Posição: Piso
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir no piso; Nome: 30x30x30 cm; Classe: Caixa de passagem - embutir; Tipo: Alvenaria - piso; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Alvenaria - piso
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Alvenaria - 300x300x300mm: 1; Caixa de passagem - embutir - Alvenaria - Tampa 300x300x50mm: 1

# IfcJunctionBox: Aço pintada - baixa, CX1
In: CAIXA D AGUA
Type - PredefinedType: POWER
AltoQi_Builder - Comprimento: 18 cm; Largura: 8.2 cm; Profundidade: 18 cm; Indicação: 180x180x82; Posição: Baixa
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir na parede; Nome: 180x180x82 mm; Classe: Caixa de passagem - embutir; Tipo: Aço pintada - baixa; Rede: Elétrica (QD)
Pset_JunctionBoxTypeCommon - Reference: Aço pintada - baixa
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Aço pintada - ref Cemar - 180x180x82 mm: 1

# IfcJunctionBox: Aço pintada - teto (35)
Type - PredefinedType: POWER
AltoQi_Builder - Comprimento: 10 cm; Largura: 10 cm; Profundidade: 8 cm; Indicação: 100x100x80; Posição: Teto
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir no teto; Nome: 100x100x80 mm; Classe: Caixa de passagem - embutir; Tipo: Aço pintada - teto
Pset_JunctionBoxTypeCommon - Reference: Aço pintada - teto
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Aço pintada - ref Lukbox - 100x100x80 mm: 1
Name | In | Rede
CX179 | Térreo | Elétrica (QD)
CX180 | Térreo | Elétrica (QD)
CX181 | Térreo | Elétrica (QD)
CX182 | Térreo | Elétrica
CX187 | Térreo | Elétrica
CX188 | Térreo | Elétrica
CX190 | Térreo | Elétrica
CX192 | Térreo | Elétrica
CX193 | Térreo | Elétrica
CX2 | Térreo | Cabeamento
CX203 | Térreo | Elétrica
CX1 | PAV 1 | Cabeamento
CX109 | PAV 1 | Elétrica
CX110 | PAV 1 | Elétrica
CX112 | PAV 1 | Elétrica
CX113 | PAV 1 | Elétrica (QD)
CX114 | PAV 1 | Elétrica
CX118 | PAV 1 | Elétrica (QD)
CX119 | PAV 1 | Elétrica (QD)
CX120 | PAV 1 | Elétrica (QD)
CX121 | PAV 1 | Elétrica
CX3 | PAV 1 | Cabeamento
CX4 | PAV 1 | Cabeamento
CX1 | PAV 2 | Cabeamento
CX204 | PAV 2 | Elétrica (QD)
CX223 | PAV 2 | Elétrica
CX271 | PAV 2 | Elétrica (QD)
CX272 | PAV 2 | Elétrica (QD)
CX276 | PAV 2 | Elétrica (ARC)
CX283 | PAV 2 | Elétrica (QD)
CX284 | PAV 2 | Elétrica (ARC)
CX285 | PAV 2 | Elétrica
CX316 | PAV 2 | Elétrica (ARC)
CX317 | PAV 2 | Elétrica (ARC)
CX318 | PAV 2 | Elétrica (ARC)

# IfcJunctionBox: Caixa de inspeção (2)
In: Térreo
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 30 cm; Largura: 30 cm; Profundidade: 30 cm; Posição: Piso
Identificação_Elemento - Aplicação: Caixa de inspeção; Descrição: Caixa de inspeção - Cimento - Ø300x300m c/ haste 5/8" x 3,00m; Nome: Cimento - Ø300x300mm c/ haste 5/8" x 3,00; Classe: SPDA - Aterramento; Tipo: Caixa de inspeção; Rede: SPDA
Pset_JunctionBoxTypeCommon - Reference: Caixa de inspeção
AltoQi_QiBuilder-Itens_Associados - Aterramento - Caixa de inspeção - Cimento - Ø300x300mm: 1; Aterramento - Haste de aterramento - cobreada - 5/8" x 3,00m: 1
Name
CXi1
CXi2

# IfcJunctionBox: Dispositivo de Cabeamento - embutir (8)
AltoQi_Builder - Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Indicação: WIFI; Posição: Alta
AltoQi_Builder-Ponto1 - Quantidade: 1; Tipo de ponto: Ponto de telecomunicações
Identificação_Elemento - Aplicação: Caixa; Descrição: Ponto para WIFI; Nome: 1 Módulo para WiFi - alta; Classe: - TEMPLATE CABEAMENTO; Tipo: Dispositivo de Cabeamento - embutir; Rede: Cabeamento
Circuito - Quadro_1: FD1
Pset_JunctionBoxTypeCommon - Reference: Dispositivo de Cabeamento - embutir
AltoQi_QiBuilder-Itens_Associados - - DISPOSITIVOS CABEAMENTO - PLACA EM PVC 2x4" - PLACA 4x2" EM PVC PARA UMA FUNÇÃO RJ-45. FORNECIMENTO E INSTALAÇÃO: 1; - DISPOSITIVOS CABEAMENTO - S/ PLACA - CONECTOR MODULAR DE 8 VIAS, FÊMEA, RJ-45, CATEGORIA 6. FORNECIMENTO E INSTALAÇÃO.: 1; .BIMFLIX - INFRAESTRUTURA - CAIXAS DE EMBUTIR - CAIXA DE PASSAGEM DE EMBUTIR, PVC, DIMENSÕES 4x2". FORNECIMENTO E INSTALAÇÃO.: 1
Name | In | Circuito_1 | Pavimento_do_circuito_1
 | Térreo | 24 - | Térreo
 | Térreo | 25 - | Térreo
 | Térreo | 26 - | Térreo
 | PAV 1 | 9 - | PAV 1
 | PAV 2 | 37 - | PAV 2
 | PAV 2 | 38 - | PAV 2
 | PAV 2 | 39 - | PAV 2
 | PAV 2 | 40 - | PAV 2

# IfcJunctionBox: PVC - alta (41)
Type - PredefinedType: POWER
AltoQi_Builder - Posição: Alta
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Tipo: PVC - alta
Pset_JunctionBoxTypeCommon - Reference: PVC - alta
Name | In | Comprimento (cm) | Largura (cm) | Profundidade (cm) | Indicação | Descrição | Nome | Classe | Rede | Acessórios p/ eletrodutos - Caixa PVC - 4x2"
CX1 | Térreo | 12 | 7.5 | 12 | 120x120x75 | Caixa de passagem de sobrepor na parede | 120x120x75 mm | Caixa de passagem - sobrepor | Cabeamento | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - PVC - ref Cemar - 120x120x75 mm: 1
CX173 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX175 | Térreo | 25 | 8 | 20 | 250x200 | Caixa de passagem de sobrepor na parede | 250x200 mm | Caixa de passagem - sobrepor | Elétrica (QD) | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - PVC - ref Krona - 25x20 mm: 1
CX178 | Térreo | 25 | 8 | 20 | 250x200 | Caixa de passagem de sobrepor na parede | 250x200 mm | Caixa de passagem - sobrepor | Elétrica (QD) | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - PVC - ref Krona - 25x20 mm: 1
CX183 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX204 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX205 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX206 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX207 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX208 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX209 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX210 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX211 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX212 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX213 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX214 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX215 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX78 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX79 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX80 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX81 | Térreo | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX104 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX105 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX106 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX107 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX108 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX2 | PAV 1 | 12 | 7.5 | 12 | 120x120x75 | Caixa de passagem de sobrepor na parede | 120x120x75 mm | Caixa de passagem - sobrepor | Cabeamento | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - PVC - ref Cemar - 120x120x75 mm: 1
CX58 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX59 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX60 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX61 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX62 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX63 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX91 | PAV 1 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX92 | PAV 1 | 25 | 8 | 20 | 250x200 | Caixa de passagem de sobrepor na parede | 250x200 mm | Caixa de passagem - sobrepor | Elétrica | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - PVC - ref Krona - 25x20 mm: 1
CX93 | PAV 1 | 25 | 8 | 20 | 250x200 | Caixa de passagem de sobrepor na parede | 250x200 mm | Caixa de passagem - sobrepor | Elétrica | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - PVC - ref Krona - 25x20 mm: 1
CX2 | PAV 2 | 12 | 7.5 | 12 | 120x120x75 | Caixa de passagem de sobrepor na parede | 120x120x75 mm | Caixa de passagem - sobrepor | Cabeamento | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - PVC - ref Cemar - 120x120x75 mm: 1
CX203 | PAV 2 | 25 | 8 | 20 | 250x200 | Caixa de passagem de sobrepor na parede | 250x200 mm | Caixa de passagem - sobrepor | Elétrica | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - PVC - ref Krona - 25x20 mm: 1
CX297 | PAV 2 | 7 | 4.75 | 10.85 | 2x4" | Caixa de passagem de embutir na parede | 2x4" | Caixa de passagem - embutir | Elétrica | 1
CX2 | CAIXA D AGUA | 25 | 8 | 20 | 250x200 | Caixa de passagem de sobrepor na parede | 250x200 mm | Caixa de passagem - sobrepor | Elétrica (ARC) | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - PVC - ref Krona - 25x20 mm: 1
CX4 | CAIXA D AGUA | 25 | 8 | 20 | 250x200 | Caixa de passagem de sobrepor na parede | 250x200 mm | Caixa de passagem - sobrepor | Elétrica (QD) | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - sobrepor - PVC - ref Krona - 25x20 mm: 1

# IfcJunctionBox: PVC - baixa, CX3
In: CAIXA D AGUA
Type - PredefinedType: POWER
AltoQi_Builder - Comprimento: 17.2 cm; Largura: 7.5 cm; Profundidade: 23 cm; Indicação: 250x200; Posição: Baixa
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir na parede; Nome: 250x200 mm; Classe: Caixa de passagem - embutir; Tipo: PVC - baixa; Rede: Elétrica (ARC)
Pset_JunctionBoxTypeCommon - Reference: PVC - baixa
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - PVC - ref Krona - 25x20 mm: 1

# IfcJunctionBox: PVC - teto (300)
Type - PredefinedType: POWER
AltoQi_Builder - Comprimento: 10 cm; Largura: 10 cm; Profundidade: 5 cm; Posição: Teto
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir na parede; Nome: 3x3"; Classe: Caixa de passagem - embutir; Tipo: PVC - teto
Pset_JunctionBoxTypeCommon - Reference: PVC - teto
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC octogonal - 3x3": 1
Name | In | Rede
88 | Térreo | Elétrica
CX1 | Térreo | Elétrica
CX100 | Térreo | Elétrica
CX101 | Térreo | Elétrica
CX102 | Térreo | Elétrica
CX103 | Térreo | Elétrica
CX104 | Térreo | Elétrica
CX105 | Térreo | Elétrica
CX106 | Térreo | Elétrica
CX107 | Térreo | Elétrica
CX108 | Térreo | Elétrica
CX109 | Térreo | Elétrica
CX110 | Térreo | Elétrica
CX111 | Térreo | Elétrica
CX112 | Térreo | Elétrica
CX113 | Térreo | Elétrica
CX114 | Térreo | Elétrica
CX115 | Térreo | Elétrica
CX116 | Térreo | Elétrica
CX117 | Térreo | Elétrica
CX118 | Térreo | Elétrica
CX119 | Térreo | Elétrica
CX121 | Térreo | Elétrica
CX122 | Térreo | Elétrica
CX123 | Térreo | Elétrica
CX124 | Térreo | Elétrica
CX125 | Térreo | Elétrica
CX126 | Térreo | Elétrica
CX127 | Térreo | Elétrica
CX128 | Térreo | Elétrica
CX129 | Térreo | Elétrica
CX130 | Térreo | Elétrica
CX131 | Térreo | Elétrica
CX132 | Térreo | Elétrica
CX133 | Térreo | Elétrica
CX134 | Térreo | Elétrica
CX135 | Térreo | Elétrica
CX136 | Térreo | Elétrica
CX137 | Térreo | Elétrica
CX138 | Térreo | Elétrica
CX139 | Térreo | Elétrica
CX140 | Térreo | Elétrica
CX141 | Térreo | Elétrica
CX142 | Térreo | Elétrica
CX143 | Térreo | Elétrica
CX144 | Térreo | Elétrica
CX145 | Térreo | Elétrica
CX146 | Térreo | Elétrica
CX147 | Térreo | Elétrica
CX148 | Térreo | Elétrica
CX149 | Térreo | Elétrica
CX150 | Térreo | Elétrica
CX151 | Térreo | Elétrica
CX152 | Térreo | Elétrica
CX153 | Térreo | Elétrica
CX154 | Térreo | Elétrica
CX155 | Térreo | Elétrica
CX156 | Térreo | Elétrica
CX157 | Térreo | Elétrica
CX158 | Térreo | Elétrica
CX159 | Térreo | Elétrica
CX16 | Térreo | Elétrica
CX160 | Térreo | Elétrica
CX161 | Térreo | Elétrica
CX162 | Térreo | Elétrica
CX163 | Térreo | Elétrica
CX164 | Térreo | Elétrica
CX165 | Térreo | Elétrica
CX166 | Térreo | Elétrica
CX167 | Térreo | Elétrica
CX168 | Térreo | Elétrica
CX169 | Térreo | Elétrica
CX17 | Térreo | Elétrica
CX18 | Térreo | Elétrica
CX185 | Térreo | Elétrica
CX189 | Térreo | Elétrica
CX19 | Térreo | Elétrica
CX194 | Térreo | Elétrica
CX195 | Térreo | Elétrica
CX196 | Térreo | Elétrica
CX2 | Térreo | Elétrica
CX20 | Térreo | Elétrica
CX200 | Térreo | Elétrica
CX201 | Térreo | Elétrica
CX21 | Térreo | Elétrica
CX22 | Térreo | Elétrica
CX23 | Térreo | Elétrica
CX24 | Térreo | Elétrica
CX25 | Térreo | Elétrica
CX26 | Térreo | Elétrica
CX27 | Térreo | Elétrica
CX28 | Térreo | Elétrica
CX29 | Térreo | Elétrica
CX3 | Térreo | Cabeamento
CX3 | Térreo | Elétrica
CX30 | Térreo | Elétrica
CX31 | Térreo | Elétrica
CX32 | Térreo | Elétrica
CX33 | Térreo | Elétrica
CX34 | Térreo | Elétrica
CX35 | Térreo | Elétrica
CX36 | Térreo | Elétrica
CX37 | Térreo | Elétrica
CX38 | Térreo | Elétrica
CX39 | Térreo | Elétrica
CX4 | Térreo | Elétrica
CX40 | Térreo | Elétrica
CX41 | Térreo | Elétrica
CX42 | Térreo | Elétrica
CX43 | Térreo | Elétrica
CX44 | Térreo | Elétrica
CX45 | Térreo | Elétrica
CX46 | Térreo | Elétrica
CX47 | Térreo | Elétrica
CX48 | Térreo | Elétrica
CX49 | Térreo | Elétrica
CX5 | Térreo | Elétrica
CX50 | Térreo | Elétrica
CX51 | Térreo | Elétrica
CX52 | Térreo | Elétrica
CX53 | Térreo | Elétrica
CX54 | Térreo | Elétrica
CX55 | Térreo | Elétrica
CX56 | Térreo | Elétrica
CX57 | Térreo | Elétrica
CX58 | Térreo | Elétrica
CX59 | Térreo | Elétrica
CX6 | Térreo | Elétrica
CX60 | Térreo | Elétrica
CX61 | Térreo | Elétrica
CX62 | Térreo | Elétrica
CX63 | Térreo | Elétrica
CX65 | Térreo | Elétrica
CX66 | Térreo | Elétrica
CX67 | Térreo | Elétrica
CX68 | Térreo | Elétrica
CX69 | Térreo | Elétrica
CX70 | Térreo | Elétrica
CX71 | Térreo | Elétrica
CX72 | Térreo | Elétrica
CX73 | Térreo | Elétrica
CX74 | Térreo | Elétrica
CX75 | Térreo | Elétrica
CX76 | Térreo | Elétrica
CX82 | Térreo | Elétrica
CX83 | Térreo | Elétrica
CX84 | Térreo | Elétrica
CX85 | Térreo | Elétrica
CX86 | Térreo | Elétrica
CX87 | Térreo | Elétrica
CX89 | Térreo | Elétrica
CX90 | Térreo | Elétrica
CX93 | Térreo | Elétrica
CX94 | Térreo | Elétrica
CX95 | Térreo | Elétrica
CX96 | Térreo | Elétrica
CX97 | Térreo | Elétrica
CX98 | Térreo | Elétrica
CX99 | Térreo | Elétrica
CX100 | PAV 1 | Elétrica
CX101 | PAV 1 | Elétrica
CX102 | PAV 1 | Elétrica
CX103 | PAV 1 | Elétrica
CX111 | PAV 1 | Elétrica
CX117 | PAV 1 | Elétrica
CX54 | PAV 1 | Elétrica
CX55 | PAV 1 | Elétrica
CX56 | PAV 1 | Elétrica
CX57 | PAV 1 | Elétrica
CX64 | PAV 1 | Elétrica
CX65 | PAV 1 | Elétrica
CX66 | PAV 1 | Elétrica
CX67 | PAV 1 | Elétrica
CX68 | PAV 1 | Elétrica
CX69 | PAV 1 | Elétrica
CX70 | PAV 1 | Elétrica
CX71 | PAV 1 | Elétrica
CX72 | PAV 1 | Elétrica
CX73 | PAV 1 | Elétrica
CX74 | PAV 1 | Elétrica
CX75 | PAV 1 | Elétrica
CX76 | PAV 1 | Elétrica
CX77 | PAV 1 | Elétrica
CX78 | PAV 1 | Elétrica
CX79 | PAV 1 | Elétrica
CX80 | PAV 1 | Elétrica
CX82 | PAV 1 | Elétrica
CX84 | PAV 1 | Elétrica
CX85 | PAV 1 | Elétrica
CX87 | PAV 1 | Elétrica
CX88 | PAV 1 | Elétrica
CX89 | PAV 1 | Elétrica
CX94 | PAV 1 | Elétrica
CX95 | PAV 1 | Elétrica
CX96 | PAV 1 | Elétrica
CX97 | PAV 1 | Elétrica
CX98 | PAV 1 | Elétrica
CX99 | PAV 1 | Elétrica
CX205 | PAV 2 | Elétrica
CX206 | PAV 2 | Elétrica
CX207 | PAV 2 | Elétrica
CX208 | PAV 2 | Elétrica
CX209 | PAV 2 | Elétrica
CX210 | PAV 2 | Elétrica
CX211 | PAV 2 | Elétrica
CX212 | PAV 2 | Elétrica
CX213 | PAV 2 | Elétrica
CX214 | PAV 2 | Elétrica
CX215 | PAV 2 | Elétrica
CX216 | PAV 2 | Elétrica
CX217 | PAV 2 | Elétrica
CX218 | PAV 2 | Elétrica
CX219 | PAV 2 | Elétrica
CX220 | PAV 2 | Elétrica
CX221 | PAV 2 | Elétrica
CX222 | PAV 2 | Elétrica
CX224 | PAV 2 | Elétrica
CX225 | PAV 2 | Elétrica
CX226 | PAV 2 | Elétrica
CX227 | PAV 2 | Elétrica
CX228 | PAV 2 | Elétrica
CX229 | PAV 2 | Elétrica
CX230 | PAV 2 | Elétrica
CX231 | PAV 2 | Elétrica
CX232 | PAV 2 | Elétrica
CX233 | PAV 2 | Elétrica
CX234 | PAV 2 | Elétrica
CX235 | PAV 2 | Elétrica
CX236 | PAV 2 | Elétrica
CX237 | PAV 2 | Elétrica
CX238 | PAV 2 | Elétrica
CX239 | PAV 2 | Elétrica
CX240 | PAV 2 | Elétrica
CX241 | PAV 2 | Elétrica
CX242 | PAV 2 | Elétrica
CX243 | PAV 2 | Elétrica
CX244 | PAV 2 | Elétrica
CX245 | PAV 2 | Elétrica
CX246 | PAV 2 | Elétrica
CX247 | PAV 2 | Elétrica
CX248 | PAV 2 | Elétrica
CX249 | PAV 2 | Elétrica
CX250 | PAV 2 | Elétrica
CX251 | PAV 2 | Elétrica
CX252 | PAV 2 | Elétrica
CX253 | PAV 2 | Elétrica
CX254 | PAV 2 | Elétrica
CX255 | PAV 2 | Elétrica
CX256 | PAV 2 | Elétrica
CX257 | PAV 2 | Elétrica
CX258 | PAV 2 | Elétrica
CX259 | PAV 2 | Elétrica
CX260 | PAV 2 | Elétrica
CX261 | PAV 2 | Elétrica
CX262 | PAV 2 | Elétrica
CX263 | PAV 2 | Elétrica
CX264 | PAV 2 | Elétrica
CX265 | PAV 2 | Elétrica
CX266 | PAV 2 | Elétrica
CX267 | PAV 2 | Elétrica
CX268 | PAV 2 | Elétrica
CX269 | PAV 2 | Elétrica
CX270 | PAV 2 | Elétrica
CX273 | PAV 2 | Elétrica
CX274 | PAV 2 | Elétrica
CX275 | PAV 2 | Elétrica
CX277 | PAV 2 | Elétrica
CX278 | PAV 2 | Elétrica
CX279 | PAV 2 | Elétrica
CX280 | PAV 2 | Elétrica
CX281 | PAV 2 | Elétrica
CX282 | PAV 2 | Elétrica
CX286 | PAV 2 | Elétrica
CX287 | PAV 2 | Elétrica
CX288 | PAV 2 | Elétrica
CX289 | PAV 2 | Elétrica
CX290 | PAV 2 | Elétrica
CX291 | PAV 2 | Elétrica
CX292 | PAV 2 | Elétrica
CX294 | PAV 2 | Elétrica
CX295 | PAV 2 | Elétrica
CX296 | PAV 2 | Elétrica
CX298 | PAV 2 | Elétrica
CX299 | PAV 2 | Elétrica
CX300 | PAV 2 | Elétrica
CX301 | PAV 2 | Elétrica
CX302 | PAV 2 | Elétrica
CX303 | PAV 2 | Elétrica
CX304 | PAV 2 | Elétrica
CX305 | PAV 2 | Elétrica
CX306 | PAV 2 | Elétrica
CX307 | PAV 2 | Elétrica
CX308 | PAV 2 | Elétrica
CX309 | PAV 2 | Elétrica
CX310 | PAV 2 | Elétrica
CX311 | PAV 2 | Elétrica
CX312 | PAV 2 | Elétrica
CX313 | PAV 2 | Elétrica
CX314 | PAV 2 | Elétrica
CX315 | PAV 2 | Elétrica

# IfcJunctionBox: Placa cega - alta, CX115
In: PAV 1
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Indicação: 2x4"; Posição: Alta
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa 2x4" com placa cega de embutir na parede; Nome: 2x4"; Classe: Caixa de passagem - embutir; Tipo: Placa cega - alta; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Placa cega - alta
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Placa cega: 1

# IfcJunctionBox: Placa cega - média (2)
In: Térreo
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Indicação: 2x4"; Posição: Média
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa 2x4" com placa cega de embutir na parede; Nome: 2x4"; Classe: Caixa de passagem - embutir; Tipo: Placa cega - média; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Placa cega - média
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Placa cega: 1
Name
CX184
CX191

# IfcJunctionBox: Pontos de cabeamento (66)
Type - PredefinedType: DATA
AltoQi_Builder - Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Indicação: RJ45(1); Posição: Baixa
AltoQi_Builder-Ponto1 - Quantidade: 1; Tipo de ponto: Ponto de telecomunicações
Identificação_Elemento - Aplicação: Caixa; Descrição: Tomada RJ45 a 0,30m do piso; Nome: RJ 45 - 1 módulo - baixa; Classe: Biblioteca BIM - Lógica; Tipo: Pontos de cabeamento; Rede: Cabeamento
Circuito - Quadro_1: FD1
Pset_JunctionBoxTypeCommon - Reference: Pontos de cabeamento
AltoQi_QiBuilder-Itens_Associados - Acessórios Cabeamento - Metálico - Conector - RJ45 - CM8v: 1; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1; Dispositivo de Cabeamento - embutir - Placa 2x4" - Bege - 1 módulo - RJ45: 1
Name | In | Circuito_1 | Pavimento_do_circuito_1
 | Térreo | 1 - | Térreo
 | Térreo | 2 - | Térreo
 | Térreo | 3 - | Térreo
 | Térreo | 4 - | Térreo
 | Térreo | 5 - | Térreo
 | Térreo | 6 - | Térreo
 | Térreo | 7 - | Térreo
 | Térreo | 8 - | Térreo
 | Térreo | 9 - | Térreo
 | Térreo | 10 - | Térreo
 | Térreo | 11 - | Térreo
 | Térreo | 12 - | Térreo
 | Térreo | 13 - | Térreo
 | Térreo | 14 - | Térreo
 | Térreo | 15 - | Térreo
 | Térreo | 16 - | Térreo
 | Térreo | 17 - | Térreo
 | Térreo | 18 - | Térreo
 | Térreo | 19 - | Térreo
 | Térreo | 20 - | Térreo
 | Térreo | 21 - | Térreo
 | Térreo | 22 - | Térreo
 | Térreo | 23 - | Térreo
 | PAV 1 | 1 - | PAV 1
 | PAV 1 | 2 - | PAV 1
 | PAV 1 | 3 - | PAV 1
 | PAV 1 | 4 - | PAV 1
 | PAV 1 | 5 - | PAV 1
 | PAV 1 | 6 - | PAV 1
 | PAV 1 | 7 - | PAV 1
 | PAV 1 | 8 - | PAV 1
 | PAV 2 | 13 - | PAV 2
 | PAV 2 | 14 - | PAV 2
 | PAV 2 | 15 - | PAV 2
 | PAV 2 | 16 - | PAV 2
 | PAV 2 | 17 - | PAV 2
 | PAV 2 | 18 - | PAV 2
 | PAV 2 | 19 - | PAV 2
 | PAV 2 | 20 - | PAV 2
 | PAV 2 | 21 - | PAV 2
 | PAV 2 | 22 - | PAV 2
 | PAV 2 | 23 - | PAV 2
 | PAV 2 | 24 - | PAV 2
 | PAV 2 | 25 - | PAV 2
 | PAV 2 | 26 - | PAV 2
 | PAV 2 | 28 - | PAV 2
 | PAV 2 | 29 - | PAV 2
 | PAV 2 | 30 - | PAV 2
 | PAV 2 | 31 - | PAV 2
 | PAV 2 | 32 - | PAV 2
 | PAV 2 | 33 - | PAV 2
 | PAV 2 | 34 - | PAV 2
 | PAV 2 | 35 - | PAV 2
 | PAV 2 | 36 - | PAV 2
 | PAV 2 | 2 - | PAV 2
 | PAV 2 | 1 - | PAV 2
 | PAV 2 | 3 - | PAV 2
 | PAV 2 | 4 - | PAV 2
 | PAV 2 | 5 - | PAV 2
 | PAV 2 | 6 - | PAV 2
 | PAV 2 | 7 - | PAV 2
 | PAV 2 | 8 - | PAV 2
 | PAV 2 | 9 - | PAV 2
 | PAV 2 | 10 - | PAV 2
 | PAV 2 | 11 - | PAV 2
 | PAV 2 | 12 - | PAV 2

# IfcJunctionBox: Pontos de comando (64)
Type - PredefinedType: POWER
AltoQi_Builder - Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Posição: Média
AltoQi_Builder-Ponto1 - Requer aterramento: Não
Identificação_Elemento - Aplicação: Caixa; Tipo: Pontos de comando; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Pontos de comando
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
Name | In | Quantidade | Tipo de ponto | Descrição | Nome | Classe | Circuito_1 | Comando_1 | Pavimento_do_circuito_1 | Quadro_1 | Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 1 tecla
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 3 - ILUMINAÇÃO - SALAS TÉRREO | q | Térreo | QD - TER 1 | 1
 | Térreo | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | f | Térreo | QD - TER 1 | Circuito - Circuito_2: 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01; Comando_2: g; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | h | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | i | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 3 - ILUMINAÇÃO - SALAS TÉRREO | r | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | j | Térreo | QD - TER 1 | 1
 | Térreo | 3 | Interruptor simples | Interruptor simples 3 teclas - 1,20m do piso | Interruptor simples - 3 teclas | Biblioteca BIM - Elétrica | 3 - ILUMINAÇÃO - SALAS TÉRREO | s | Térreo | QD - TER 1 | Circuito - Circuito_2: 3 - ILUMINAÇÃO - SALAS TÉRREO; Comando_2: t; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; Circuito_3: 3 - ILUMINAÇÃO - SALAS TÉRREO; Comando_3: u; Pavimento_do_circuito_3: Térreo; Quadro_3: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 3 teclas: 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | k | Térreo | QD - TER 1 | 1
 | Térreo | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 7 - ILUMINAÇÃO - CINEMA | o1 | Térreo | QD - TER 1 | Circuito - Circuito_2: 7 - ILUMINAÇÃO - CINEMA; Comando_2: p1; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 6 - ILUMINAÇÃO - PISO EXTERNA | l1 | Térreo | QD - TER 1 | 1
 | Térreo | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA | d | Térreo | QD - TER 1 | Circuito - Circuito_2: 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA; Comando_2: e; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 4 - ILUMINAÇÃO - BANHEIROS | a1 | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 4 - ILUMINAÇÃO - BANHEIROS | b1 | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Dimmer | Interruptor variável 1 tecla - 1,10m do piso | Dimmer rotativo - 1 tecla | 0 - LUMOS - Biblioteca BIM - Elétrica | 7 - ILUMINAÇÃO - CINEMA | m1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Dimmer rotativo: 1
 | Térreo | 1 | Dimmer | Interruptor variável 1 tecla - 1,10m do piso | Dimmer rotativo - 1 tecla | 0 - LUMOS - Biblioteca BIM - Elétrica | 7 - ILUMINAÇÃO - CINEMA | n1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Dimmer rotativo: 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA | a | Térreo | QD - TER 1 | 1
 | Térreo | 3 | Interruptor simples | Interruptor simples 3 teclas - 1,20m do piso | Interruptor simples - 3 teclas | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA | b | Térreo | QD - TER 1 | Circuito - Circuito_2: 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA; Comando_2: c; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; Circuito_3: 11 - TOMADAS - RECPÇÃO E ENTRADA; Comando_3: q1; Pavimento_do_circuito_3: Térreo; Quadro_3: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 3 teclas: 1
 | Térreo | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - CAFÉ | c1 | Térreo | QD - TER 1 | Circuito - Circuito_2: 5 - ILUMINAÇÃO - CAFÉ; Comando_2: d1; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | Térreo | 3 | Interruptor simples | Interruptor simples 3 teclas - 1,20m do piso | Interruptor simples - 3 teclas | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - CAFÉ | e1 | Térreo | QD - TER 1 | Circuito - Circuito_2: 5 - ILUMINAÇÃO - CAFÉ; Comando_2: f1; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; Circuito_3: 5 - ILUMINAÇÃO - CAFÉ; Comando_3: g1; Pavimento_do_circuito_3: Térreo; Quadro_3: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 3 teclas: 1
 | Térreo | 3 | Interruptor simples | Interruptor simples 3 teclas - 1,20m do piso | Interruptor simples - 3 teclas | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - CAFÉ | h1 | Térreo | QD - TER 1 | Circuito - Circuito_2: 5 - ILUMINAÇÃO - CAFÉ; Comando_2: i1; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; Circuito_3: 5 - ILUMINAÇÃO - CAFÉ; Comando_3: j1; Pavimento_do_circuito_3: Térreo; Quadro_3: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 3 teclas: 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - CAFÉ | k1 | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 4 - ILUMINAÇÃO - BANHEIROS | v | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 4 - ILUMINAÇÃO - BANHEIROS | w | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 4 - ILUMINAÇÃO - BANHEIROS | x | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 4 - ILUMINAÇÃO - BANHEIROS | y | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 4 - ILUMINAÇÃO - BANHEIROS | z | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 3 - ILUMINAÇÃO - SALAS TÉRREO | l | Térreo | QD - TER 1 | 1
 | Térreo | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 3 - ILUMINAÇÃO - SALAS TÉRREO | m | Térreo | QD - TER 1 | 1
 | Térreo | 3 | Interruptor simples | Interruptor simples 3 teclas - 1,20m do piso | Interruptor simples - 3 teclas | Biblioteca BIM - Elétrica | 3 - ILUMINAÇÃO - SALAS TÉRREO | n | Térreo | QD - TER 1 | Circuito - Circuito_2: 3 - ILUMINAÇÃO - SALAS TÉRREO; Comando_2: o; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; Circuito_3: 3 - ILUMINAÇÃO - SALAS TÉRREO; Comando_3: p; Pavimento_do_circuito_3: Térreo; Quadro_3: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 3 teclas: 1
 | PAV 1 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - CIRCULAÇÃO | a | PAV 1 | QD - PAV 1 | 1
 | PAV 1 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - CIRCULAÇÃO | b | PAV 1 | QD - PAV 1 | 1
 | PAV 1 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - CIRCULAÇÃO | c | PAV 1 | QD - PAV 1 | 1
 | PAV 1 | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 2 - ILUMINAÇÃO - SALA PAV 1 | l | PAV 1 | QD - PAV 1 | Circuito - Circuito_2: 2 - ILUMINAÇÃO - SALA PAV 1; Comando_2: m; Pavimento_do_circuito_2: PAV 1; Quadro_2: QD - PAV 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | PAV 1 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - CIRCULAÇÃO | d | PAV 1 | QD - PAV 1 | 1
 | PAV 1 | 3 | Interruptor simples | Interruptor simples 3 teclas - 1,20m do piso | Interruptor simples - 3 teclas | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - CIRCULAÇÃO | e | PAV 1 | QD - PAV 1 | Circuito - Circuito_2: 1 - ILUMINAÇÃO - CIRCULAÇÃO; Comando_2: f; Pavimento_do_circuito_2: PAV 1; Quadro_2: QD - PAV 1; Circuito_3: 1 - ILUMINAÇÃO - CIRCULAÇÃO; Comando_3: g; Pavimento_do_circuito_3: PAV 1; Quadro_3: QD - PAV 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 3 teclas: 1
 | PAV 1 | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - CIRCULAÇÃO | h | PAV 1 | QD - PAV 1 | Circuito - Circuito_2: 1 - ILUMINAÇÃO - CIRCULAÇÃO; Comando_2: i; Pavimento_do_circuito_2: PAV 1; Quadro_2: QD - PAV 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | PAV 1 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - CIRCULAÇÃO | j | PAV 1 | QD - PAV 1 | 1
 | PAV 1 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - CIRCULAÇÃO | k | PAV 1 | QD - PAV 1 | 1
 | PAV 1 | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 3 - ILUMINAÇÃO - EXTERNA | n | PAV 1 | QD - PAV 1 | Circuito - Circuito_2: 3 - ILUMINAÇÃO - EXTERNA; Comando_2: o; Pavimento_do_circuito_2: PAV 1; Quadro_2: QD - PAV 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | PAV 2 | 3 | Interruptor simples | Interruptor simples 3 teclas - 1,20m do piso | Interruptor simples - 3 teclas | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | x | PAV 2 | QD - PAV 2 | Circuito - Circuito_2: 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB.; Comando_2: y; Pavimento_do_circuito_2: PAV 2; Quadro_2: QD - PAV 2; Circuito_3: 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB.; Comando_3: z; Pavimento_do_circuito_3: PAV 2; Quadro_3: QD - PAV 2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 3 teclas: 1
 | PAV 2 | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | a1 | PAV 2 | QD - PAV 2 | Circuito - Circuito_2: 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB.; Comando_2: b1; Pavimento_do_circuito_2: PAV 2; Quadro_2: QD - PAV 2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | PAV 2 | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | c1 | PAV 2 | QD - PAV 2 | Circuito - Circuito_2: 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB.; Comando_2: d1; Pavimento_do_circuito_2: PAV 2; Quadro_2: QD - PAV 2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | e1 | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | q | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | r | PAV 2 | QD - PAV 2 | Circuito - Circuito_2: 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO; Comando_2: s; Pavimento_do_circuito_2: PAV 2; Quadro_2: QD - PAV 2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | f1 | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | g1 | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | t | PAV 2 | QD - PAV 2 | Circuito - Circuito_2: 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO; Comando_2: u; Pavimento_do_circuito_2: PAV 2; Quadro_2: QD - PAV 2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | PAV 2 | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | v | PAV 2 | QD - PAV 2 | Circuito - Circuito_2: 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO; Comando_2: w; Pavimento_do_circuito_2: PAV 2; Quadro_2: QD - PAV 2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | PAV 2 | 2 | Interruptor simples | Interruptor simples 2 teclas - 1,20m do piso | Interruptor simples - 2 teclas | Biblioteca BIM - Elétrica | 2 - ILUMINAÇÃO - SALA FRONTAL | g | PAV 2 | QD - PAV 2 | Circuito - Circuito_2: 2 - ILUMINAÇÃO - SALA FRONTAL; Comando_2: h; Pavimento_do_circuito_2: PAV 2; Quadro_2: QD - PAV 2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 2 teclas: 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 2 - ILUMINAÇÃO - SALA FRONTAL | i | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 3 - ILUMINAÇÃO - CIRCULAÇÃO I E SALA DE PROJEÇÃO | n | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 3 - ILUMINAÇÃO - CIRCULAÇÃO I E SALA DE PROJEÇÃO | o | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 2 - ILUMINAÇÃO - SALA FRONTAL | j | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 3 | Interruptor simples | Interruptor simples 3 teclas - 1,20m do piso | Interruptor simples - 3 teclas | Biblioteca BIM - Elétrica | 2 - ILUMINAÇÃO - SALA FRONTAL | k | PAV 2 | QD - PAV 2 | Circuito - Circuito_2: 2 - ILUMINAÇÃO - SALA FRONTAL; Comando_2: l; Pavimento_do_circuito_2: PAV 2; Quadro_2: QD - PAV 2; Circuito_3: 2 - ILUMINAÇÃO - SALA FRONTAL; Comando_3: m; Pavimento_do_circuito_3: PAV 2; Quadro_3: QD - PAV 2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 3 teclas: 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - SALA E BANHEIRO | a | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - SALA E BANHEIRO | b | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 3 - ILUMINAÇÃO - CIRCULAÇÃO I E SALA DE PROJEÇÃO | p | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - SALA E BANHEIRO | c | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - SALA E BANHEIRO | d | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - SALA E BANHEIRO | e | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 1 - ILUMINAÇÃO - SALA E BANHEIRO | f | PAV 2 | QD - PAV 2 | 1
 | PAV 2 | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | h1 | PAV 2 | QD - PAV 2 | 1
 | CAIXA D AGUA | 1 | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | Biblioteca BIM - Elétrica | 41 - ILUMINAÇÃO - MANUTENÇÃO | a | CAIXA D AGUA | QD - B1 | 1

# IfcJunctionBox: Pontos de força - Uso específico (11)
Type - PredefinedType: POWER
AltoQi_Builder - Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Posição: Baixa
AltoQi_Builder-Ponto1 - Quantidade: 1; Tipo de ponto: Tomada 3P+T; Requer aterramento: Sim
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de força - Uso específico
Circuito - Comando_1: Nenhum
Pset_JunctionBoxTypeCommon - Reference: Pontos de força - Uso específico
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
Name | In | Indicação | Fator de potência (%) | Potência (W) | Rendimento (%) | Descrição | Nome | Rede | Circuito_1 | Pavimento_do_circuito_1 | Quadro_1
 | Térreo | 3cv | 80 | 2200 | 83 | Ponto para motor trifásico a 0,30m do piso | Bomba - 3cv trifásico | Elétrica | 17 - BOMBA DE RECALQUE | Térreo | QD - B | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa c/ furo: 1
 | CAIXA D AGUA | 10cv | 81 | 7300 | 85.5 | Ponto para motor trifásico a 0,30m do piso | Bomba - 10cv trifásico | Elétrica | 39 - BOMBA - 2 | CAIXA D AGUA | QD - B1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa c/ furo: 1
 | CAIXA D AGUA | 10cv | 81 | 7300 | 85.5 | Ponto para motor trifásico a 0,30m do piso | Bomba - 10cv trifásico | Elétrica | 38 - BOMBA - 1 | CAIXA D AGUA | QD - B1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa c/ furo: 1
 | CAIXA D AGUA | MVC-M785WV2GN1 (28HP) | 90 | 21800 | 100 | MVC-M785WV2GN1 (28HP) | MVC-M785WV2GN1 (28HP) | Elétrica (ARC) | 32 - MVC-M670WV2GN1 (28HP) - A | CAIXA D AGUA | QD - ARC - 2
 | CAIXA D AGUA | MVC-M785WV2GN1 (28HP) | 90 | 21800 | 100 | MVC-M785WV2GN1 (28HP) | MVC-M785WV2GN1 (28HP) | Elétrica (ARC) | 33 - MVC-M670WV2GN1 (28HP) - B | CAIXA D AGUA | QD - ARC - 2
 | CAIXA D AGUA | MVC-M670WV2GN1 (24HP) | 90 | 19000 | 100 | MVC-M670WV2GN1 (24HP) | MVC-M670WV2GN1 (24HP) | Elétrica (ARC) | 30 - MVC-M670WV2GN1 (24HP) - A | CAIXA D AGUA | QD - ARC - 2
 | CAIXA D AGUA | MVC-M670WV2GN1 (24HP) | 90 | 19000 | 100 | MVC-M670WV2GN1 (24HP) | MVC-M670WV2GN1 (24HP) | Elétrica (ARC) | 31 - MVC-M670WV2GN1 (24HP) - B | CAIXA D AGUA | QD - ARC - 2
 | CAIXA D AGUA | 40DV670 | 90 | 6006 | 100 | 40DV670 | 40DV670 | Elétrica (ARC) | 29 - 40DV670 - B | CAIXA D AGUA | QD - ARC - 2
 | CAIXA D AGUA | 40DV670 | 90 | 6006 | 100 | 40DV670 | 40DV670 | Elétrica (ARC) | 28 - 40DV670 - A | CAIXA D AGUA | QD - ARC - 2
 | CAIXA D AGUA | 10cv | 82 | 7400 | 89 | Ponto para motor trifásico a 0,30m do piso | Motor para elevador - 10 cv trifásico | Elétrica | 44 - MOTOR ELEVADOR | CAIXA D AGUA | QD - ELE1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa c/ furo: 1
 | CAIXA D AGUA | MVC-M785WV2GN1 (28HP) | 90 | 21800 | 100 | MVC-M785WV2GN1 (28HP) | MVC-M785WV2GN1 (28HP) | Elétrica (ARC) | 34 - MVC-M670WV2GN1 (28HP) - C | CAIXA D AGUA | QD - ARC - 2

# IfcJunctionBox: Pontos de força - Uso geral (142)
Type - PredefinedType: POWER
AltoQi_Builder - Comprimento: 7 cm
AltoQi_Builder-Ponto1 - Fator de potência (%): 90; Rendimento (%): 100; Tipo de ponto: Tomada 2P+T; Requer aterramento: Sim
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de força - Uso geral
Pset_JunctionBoxTypeCommon - Reference: Pontos de força - Uso geral
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
Name | In | Largura (cm) | Profundidade (cm) | Posição | Potência (W) | Quantidade | Descrição | Nome | Rede | Circuito_1 | Comando_1 | Pavimento_do_circuito_1 | Quadro_1 | Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função | Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A
2 x  | Térreo | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | Elétrica | 10 - TOMADAS - LAB. 2 E SALA | Nenhum | Térreo | QD - TER 1 | 1 | 1
2 x  | Térreo | 4.75 | 10.85 | Baixa | 1000 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - 1000 W - baixa | Elétrica | 13 - EQUIPAMENTOS DE ACESSIBILIDADE | Nenhum | Térreo | QD - TER 1 | 1 | 1
 | Térreo | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 4 - AR COND.4 - TÉRREO | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | Térreo | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 5 - AR COND.5 - TÉRREO | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | Térreo | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 6 - AR COND.6 - TÉRREO | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | Térreo | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 8 - AR COND.8 - TÉRREO | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | Térreo | 4.75 | 10.85 | Alta | 200 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,20m do piso | 2P+T 10 A - 200 W - alta | Elétrica (ARC) | 7 - AR COND.7 - TÉRREO | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | Térreo | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 2 - AR COND.2 - TÉRREO | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | Térreo | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 1 - AR COND.1 - TÉRREO | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | Térreo | 4.75 | 10.85 | Alta | 600 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,20m do piso | 2P+T 10 A - 600 W - alta | Elétrica (ARC) | 3 - AR COND.3 - TÉRREO | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | Térreo | 4.75 | 10.85 | Alta | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,20m do piso | 2P+T 10 A - alta | Elétrica | 10 - TOMADAS - LAB. 2 E SALA | Nenhum | Térreo | QD - TER 1 | 1 | 1
 | Térreo | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica | 9 - TOMADAS - LAB. 1 E COZINHA | Nenhum | Térreo | QD - TER 1 | 1 | 1
3 x  | Térreo | 4.75 | 10.85 | Média | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | Elétrica | 9 - TOMADAS - LAB. 1 E COZINHA | Nenhum | Térreo | QD - TER 1 | 1 | 1
6 x  | Térreo | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | Elétrica | 9 - TOMADAS - LAB. 1 E COZINHA | Nenhum | Térreo | QD - TER 1 | 1 | 1
 | Térreo | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | Elétrica | 11 - TOMADAS - RECPÇÃO E ENTRADA | Nenhum | Térreo | QD - TER 1 | 1 | 1
4 x  | Térreo | 4.75 | 10.85 | Baixa | 100 | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | Elétrica | 11 - TOMADAS - RECPÇÃO E ENTRADA | Nenhum | Térreo | QD - TER 1 | Circuito - Circuito_2: 11 - TOMADAS - RECPÇÃO E ENTRADA; Comando_2: Nenhum; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
14 x  | Térreo | 4.75 | 10.85 | Baixa | 100 | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | Elétrica | 10 - TOMADAS - LAB. 2 E SALA | Nenhum | Térreo | QD - TER 1 | Circuito - Circuito_2: 10 - TOMADAS - LAB. 2 E SALA; Comando_2: Nenhum; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
6 x  | Térreo | 4.75 | 10.85 | Média | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | Elétrica | 12 - TOMADAS - CAFÉ | Nenhum | Térreo | QD - TER 1 | 1 | 1
2 x  | Térreo | 4.75 | 10.85 | Baixa | 20 | 1 | Ponto de conexão para iluminação no piso | Ponto de iluminação - piso | Elétrica | 11 - TOMADAS - RECPÇÃO E ENTRADA | q1 | Térreo | QD - TER 1 | 1 | 1
24 x  | Térreo | 4.75 | 10.85 | Baixa | 15 | 1 | Ponto - balizador | Ponto - balizador | Elétrica | 8 - ILUMINAÇÃO - PISO CINEMA | Nenhum | Térreo | QD - TER 1 | 1
2 x  | Térreo | 4.75 | 10.85 | Baixa | 600 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - 600 W - baixa | Elétrica | 12 - TOMADAS - CAFÉ | Nenhum | Térreo | QD - TER 1 | 1 | 1
9 x  | PAV 1 | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | Elétrica | 4 - TOMADAS - LAB. PAV. 1 | Nenhum | PAV 1 | QD - PAV 1 | 1 | 1
 | PAV 1 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,80m do piso | 2P+T 10 A - 200 W - teto | Elétrica (ARC) | 14 - AR COND.6 - PAV. 1 | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | PAV 1 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,80m do piso | 2P+T 10 A - 200 W - teto | Elétrica (ARC) | 10 - AR COND.2 - PAV. 1 | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | PAV 1 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,80m do piso | 2P+T 10 A - 200 W - teto | Elétrica (ARC) | 11 - AR COND.3 - PAV. 1 | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | PAV 1 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,80m do piso | 2P+T 10 A - 200 W - teto | Elétrica (ARC) | 12 - AR COND.4 - PAV. 1 | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | PAV 1 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,80m do piso | 2P+T 10 A - 200 W - teto | Elétrica (ARC) | 9 - AR COND.1 - PAV. 1 | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
 | PAV 1 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,80m do piso | 2P+T 10 A - 200 W - teto | Elétrica (ARC) | 13 - AR COND.5 - PAV. 1 | Nenhum | CAIXA D AGUA | QD - ARC - 1 | 1 | 1
21 x  | PAV 2 | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | Elétrica | 8 - TOMADAS - LABORATÓRIOS | Nenhum | PAV 2 | QD - PAV 2 | 1 | 1
10 x  | PAV 2 | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | Elétrica | 9 - TOMADAS - STÚDIO E SALA B | Nenhum | PAV 2 | QD - PAV 2 | 1 | 1
3 x  | PAV 2 | 4.75 | 10.85 | Média | 100 | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10A (2) - média | Elétrica | 7 - TOMADAS - SALA DE PROJEÇÃO | Nenhum | PAV 2 | QD - PAV 2 | Circuito - Circuito_2: 7 - TOMADAS - SALA DE PROJEÇÃO; Comando_2: Nenhum; Pavimento_do_circuito_2: PAV 2; Quadro_2: QD - PAV 2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
6 x  | PAV 2 | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | Elétrica | 10 - TOMADAS - SALAS A | Nenhum | PAV 2 | QD - PAV 2 | 1 | 1
 | PAV 2 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 18 - AR COND.1 - PAV. 2 | Nenhum | CAIXA D AGUA | QD - ARC - 2 | 1 | 1
 | PAV 2 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 19 - AR COND.2 - PAV. 2 | Nenhum | CAIXA D AGUA | QD - ARC - 2 | 1 | 1
 | PAV 2 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 20 - AR COND.3 - PAV. 2 | Nenhum | CAIXA D AGUA | QD - ARC - 2 | 1 | 1
 | PAV 2 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 21 - AR COND.4 - PAV. 2 | Nenhum | CAIXA D AGUA | QD - ARC - 2 | 1 | 1
 | PAV 2 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 22 - AR COND.5 - PAV. 2 | Nenhum | CAIXA D AGUA | QD - ARC - 2 | 1 | 1
 | PAV 2 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 23 - AR COND.6 - PAV. 2 | Nenhum | CAIXA D AGUA | QD - ARC - 2 | 1 | 1
 | PAV 2 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 25 - AR COND.8 - PAV. 2 | Nenhum | CAIXA D AGUA | QD - ARC - 2 | 1 | 1
 | PAV 2 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 26 - AR COND.9 - PAV. 2 | Nenhum | CAIXA D AGUA | QD - ARC - 2 | 1 | 1
 | PAV 2 | 4.75 | 10.85 | Alta | 200 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,20m do piso | 2P+T 10 A - 200 W - alta | Elétrica (ARC) | 27 - AR COND.10 - PAV. 2 | Nenhum | CAIXA D AGUA | QD - ARC - 2 | 1 | 1
 | PAV 2 | 4.75 | 10.85 | Alta | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,20m do piso | 2P+T 10 A - alta | Elétrica | 9 - TOMADAS - STÚDIO E SALA B | Nenhum | PAV 2 | QD - PAV 2 | 1 | 1
 | PAV 2 | 10.85 | 4.75 | Teto | 200 | 1 | Tomada (NBR 14136) | 2P+T 10 A - 200 W - ARC (2) | Elétrica (ARC) | 24 - AR COND.7 - PAV. 2 | Nenhum | CAIXA D AGUA | QD - ARC - 2 | 1 | 1
