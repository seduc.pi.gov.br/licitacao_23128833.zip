Properties of the parts of a building model (IFC4), part 5 of 5

# IfcJunctionBox: Racks, FD1
In: PAV 2
Type - PredefinedType: DATA
AltoQi_Builder - Comprimento: 30 cm; Largura: 30 cm; Profundidade: 11 cm; Posição: Piso
Identificação_Elemento - Aplicação: Rack; Descrição: RACK PADRÃO 19”, 12U; Nome: Rack Padrão 19”, 12U X 550 mm X 570 mm; Classe: .BIMFLIX - RACK; Tipo: Racks; Rede: Cabeamento
Pset_JunctionBoxTypeCommon - Reference: Racks
AltoQi_QiBuilder-Itens_Associados - - DISPOSITIVOS CABEAMENTO - RACK - RACK DE PAREDE PADRÃO 19”, 12U X 550 MM - LARGURA - X 570 MM - PROFUNDIDADE - , COM PORTA PERFURADA, IP20, COM CAPACIDADE MÍNIMA PARA 1.000 KG DE CARGA DINÂMICA.: 1; Acessórios Cabeamento - Metálico - Conector - RJ45 - Blindado: 40; Acessórios Cabeamento - Metálico - Patch panel - 24 posições: 3; Acessórios Cabeamento - Metálico - Switch - 10/100 - BaseTX + - 10/100/1000 - Base T - 8 + 2 - portas: 1

# IfcJunctionBox: VDI c/ tomada (ref Tigre) (2)
Type - PredefinedType: DATA
AltoQi_Builder - Comprimento: 44 cm; Largura: 10 cm; Profundidade: 44 cm; Indicação: VDI 40x40; Posição: Alta
Identificação_Elemento - Aplicação: Rack; Descrição: Quadro VDI 40x40 embutido na parede; Nome: VDI c/ tomada (ref Tigre) - Embutir - 40x40 cm - alta; Classe: .BIMFLIX - RACK; Tipo: VDI c/ tomada (ref Tigre); Rede: Cabeamento
Pset_JunctionBoxTypeCommon - Reference: VDI c/ tomada (ref Tigre)
AltoQi_QiBuilder-Itens_Associados - - DISPOSITIVOS CABEAMENTO - RACK - VDI C/ TOMADA - REF TIGRE - EMBUTIR - 40X40CM. FORNECIMENTO E INSTALAÇÃO.: 1; .BIMFLIX - DISPOSITIVO ELÉTRICO - PLACA EM PVC 2x4" - PLACA 4x2" EM PVC PARA UMA FUNÇÃO, FORNECIMENTO E INSTALAÇÃO: 1; .BIMFLIX - DISPOSITIVO ELÉTRICO - S/ PLACA - PLUG PARA TOMADA, 2P+T NBR 14136, TRÊS POLOS REDONDOS, 1 MÓDULO, CORRENTE NOMINAL 20A, TENSÃO NOMINAL 250V, TERMOPLÁSTICO FRONTAL. FORNECIMENTO E INSTALAÇÃO.: 1; .BIMFLIX - INFRAESTRUTURA - CAIXAS DE EMBUTIR - CAIXA DE PASSAGEM DE EMBUTIR, PVC, DIMENSÕES 4x2". FORNECIMENTO E INSTALAÇÃO.: 1; Acessórios Cabeamento - Metálico - Switch - 10/100 - BaseTX + - 10/100/1000 - Base T - 8 + 2 - portas: 1
Name | In | Acessórios Cabeamento - Metálico - Conector - RJ45 - Blindado | Acessórios Cabeamento - Metálico - Patch panel - 24 posições
FD1 | Térreo | 26 | 2
FD1 | PAV 1 | 9 | 1

# IfcProtectiveDevice: Barramento de equipotencialização
In: CAIXA D AGUA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 21 cm; Largura: 9 cm; Profundidade: 21 cm; Indicação: BEP; Posição: Média
Identificação_Elemento - Aplicação: Barramento de equipotencialização; Descrição: BEP - 9 terminais 210x210x90mm Metálica; Nome: 9 terminais 210x210x90mm Metálica; Classe: SPDA - Aterramento; Tipo: Barramento de equipotencialização; Rede: SPDA
Pset_ProtectiveDeviceTypeCommon - Reference: Barramento de equipotencialização
AltoQi_QiBuilder-Itens_Associados - Aterramento - Barramento de equipotencialização - 9 terminais: 1

# IfcProtectiveDevice: Captores
In: CAIXA D AGUA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Altura: 330 cm; Posição: Teto
Identificação_Elemento - Aplicação: Captor; Nome: Captor Franklin - Mastro 3m - 2 descidas; Classe: .BIMFLIX - TEMPLATE SPDA; Tipo: Captores; Rede: SPDA
Pset_ProtectiveDeviceTypeCommon - Reference: Captores
AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - SPDA - CAPTOR FRANKLIN - CAPTOR TIPO FRANKLIN COM MASTRO DE 3,0 METROS: 1; .BIMFLIX - SPDA - MASTRO - MASTRO SIMPLES - 3m x ø2": 1

# IfcProtectiveDevice: Haste de aterramento (14)
In: Térreo
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Altura: 300 cm; Indicação: H=3,00; Posição: Piso
Identificação_Elemento - Aplicação: Haste de aterramento; Descrição: cobreada - 5/8" x 3,00m; Nome: cobreada - 5/8" x 3,00m; Classe: SPDA - Aterramento; Tipo: Haste de aterramento; Rede: SPDA
Pset_ProtectiveDeviceTypeCommon - Reference: Haste de aterramento
AltoQi_QiBuilder-Itens_Associados - Aterramento - Conector tipo "U" - 5/8": 1; Aterramento - Haste de aterramento - cobreada - 5/8" x 3,00m: 1

# IfcProtectiveDevice: Terminal Aéreo (35)
In: CAIXA D AGUA
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Altura: 20 cm; Posição: Teto
Identificação_Elemento - Aplicação: Captor; Classe: SPDA - Captor; Tipo: Terminal Aéreo; Rede: SPDA
Pset_ProtectiveDeviceTypeCommon - Reference: Terminal Aéreo
Name | Descrição | Nome | Captores - Terminal Aéreo - 200 mm - Fixação vertical
26 x  | Terminal Aéreo - 200 mm - Fixação vertical | 200 mm - Fixação vertical | 1
9 x  | Terminal Aéreo - 200 mm - Fixação horizontal | 200 mm - Fixação horizontal | AltoQi_QiBuilder-Itens_Associados - Captores - Terminal Aéreo - 200 mm - Fixação horizontal: 1
