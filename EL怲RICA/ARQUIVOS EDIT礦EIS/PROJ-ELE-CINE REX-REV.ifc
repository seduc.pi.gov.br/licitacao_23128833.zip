Properties of the parts of a building model (IFC4), part 1 of 5

# File
Description: IFC4
Time: 2025-12-29T11:32:33
Made in: IfcPlusPlus

# IfcBuildingStorey (4)
Name | LongName | Elevation (cm)
Térreo | Térreo | -14
PAV 1 | PAV 1 | 301
PAV 2 | PAV 2 | 604
CAIXA D AGUA | CAIXA D AGUA | 934

# IfcBuildingElementProxy: Luminárias (349)
AltoQi_Builder-Ponto1 - Fluxo luminoso para tensão 12V: 0 lm; Número de lâmpadas: 1; Quantidade: 1; Rendimento (%): 100; Tipo de ponto: Lâmpada
Identificação_Elemento - Aplicação: Caixa; Classe: .BIMFLIX - TEMPLATE ELÉTRICA; Tipo: Luminárias; Rede: Elétrica
Pset_BuildingElementProxyTypeCommon - Reference: Luminárias
Name | In | Comprimento (cm) | Largura (cm) | Profundidade (cm) | Posição | Fator de potência (%) | Fluxo luminoso para tensão 127V (lm) = Fluxo luminoso para tensão 220V (lm) | Potência (W) | Tipo de luminária | Requer aterramento | Nome | Circuito_1 | Comando_1 | Pavimento_do_circuito_1 | Quadro_1
2 x  | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 4 - ILUMINAÇÃO - BANHEIROS | v | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
 | Térreo | 500 | 3 | 3 | Teto | 75 | 1440 | 40 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 5M- LAB | 3 - ILUMINAÇÃO - SALAS TÉRREO | u | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
 | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | Nenhum | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
5 x  | Térreo | 15 | 15 | 11 | Piso | 75 | 280 | 9 | A1 (Direta) | Não | Luminária de Sobrepor PAREDE | 5 - ILUMINAÇÃO - CAFÉ | i1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE PAREDE: 1
 | Térreo | 7 | 4.75 | 10.85 | Alta | 100 | 1311 | 60 | A1 (Direta) | Sim | ARANDELA - ESFERA 60 W | 6 - ILUMINAÇÃO - ESCADARIA | Nenhum | PAV 2 | QD - PAV 2 | Identificação_Elemento - Descrição: ARANDELA 60W; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA DE EMBUTIR ARANDELA: 100 cm; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
7 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 5 - ILUMINAÇÃO - CAFÉ | c1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
4 x  | Térreo | 7.5 | 10 | 15 | Alta | 90 | 700 | 20 | A2.1 (Direta) | Sim | Canhão de LED | 3 - ILUMINAÇÃO - SALAS TÉRREO | q | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - CANHÃO DE LED DIRECIONÁVEL: 1
2 x  | Térreo | 400 | 3 | 3 | Teto | 75 | 1440 | 36 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 4M - STD | 5 - ILUMINAÇÃO - CAFÉ | g1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
6 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA | d | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
4 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA | a | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | Térreo | 9 | 9 | 3 | Teto | 92 | 380 | 55.2 | A3 (Direta) | Sim | Luminária de Sobrepor - Pontos de Luz - NBR 5410 - 9x9cm 60VA | 5 - ILUMINAÇÃO - CAFÉ | d1 | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 60VA; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - INFRAESTRUTURA - CONDULETE CARREGADO - CONDULETE TIPO X DE Ø1", PARA TOMADAS/INTERRUPTORES, FORNECIMENTO E INSTALAÇÃO.: 1
15 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA | b | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
4 x  | Térreo | 3 | 3 | 400 | Teto | 75 | 1440 | 36 | A1 (Direta) | Sim | Fitas Led - VERTICAL 4M | 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA | c | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
2 x  | Térreo | 200 | 3 | 3 | Teto | 75 | 1440 | 20 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 5.5M | 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA | c | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
18 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 7 - ILUMINAÇÃO - CINEMA | m1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | Térreo | 300 | 3 | 3 | Teto | 75 | 1440 | 27 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 3M -CIRC | 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA | e | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
6 x  | Térreo | 7 | 4.75 | 10.85 | Alta | 100 | 1311 | 60 | A1 (Direta) | Sim | ARANDELA - ESFERA 60 W | 7 - ILUMINAÇÃO - CINEMA | p1 | Térreo | QD - TER 1 | Identificação_Elemento - Descrição: ARANDELA 60W; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA DE EMBUTIR ARANDELA: 100 cm; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
5 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 5 - ILUMINAÇÃO - CAFÉ | j1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
18 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 7 - ILUMINAÇÃO - CINEMA | n1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
4 x  | Térreo | 200 | 3 | 3 | Teto | 75 | 1440 | 20 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 2.7M | 1 - ILUMINAÇÃO - RECEPÇÃO E ENTRADA | c | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
2 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | f | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
4 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | h | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | g | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
6 x  | Térreo | 200 | 3 | 3 | Teto | 75 | 1440 | 20 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 2M -CIRC | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | g | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
4 x  | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | i | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
 | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 3 - ILUMINAÇÃO - SALAS TÉRREO | r | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
3 x  | Térreo | 200 | 3 | 3 | Teto | 75 | 1440 | 20 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 2M -CIRC | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | j | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
2 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | j | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
5 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 3 - ILUMINAÇÃO - SALAS TÉRREO | t | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
5 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 3 - ILUMINAÇÃO - SALAS TÉRREO | s | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
3 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 4 - ILUMINAÇÃO - BANHEIROS | b1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
3 x  | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 3 - ILUMINAÇÃO - SALAS TÉRREO | n | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
3 x  | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 3 - ILUMINAÇÃO - SALAS TÉRREO | o | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
3 x  | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 3 - ILUMINAÇÃO - SALAS TÉRREO | p | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
 | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 3 - ILUMINAÇÃO - SALAS TÉRREO | l | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
2 x  | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 3 - ILUMINAÇÃO - SALAS TÉRREO | m | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
2 x  | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 4 - ILUMINAÇÃO - BANHEIROS | z | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
2 x  | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 4 - ILUMINAÇÃO - BANHEIROS | y | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
 | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 4 - ILUMINAÇÃO - BANHEIROS | w | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
 | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 4 - ILUMINAÇÃO - BANHEIROS | x | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
 | Térreo | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 5 - ILUMINAÇÃO - CAFÉ | k1 | Térreo | QD - TER 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
6 x  | Térreo | 7 | 4.75 | 10.85 | Alta | 100 | 1311 | 60 | A1 (Direta) | Sim | ARANDELA - ESFERA 60 W | 7 - ILUMINAÇÃO - CINEMA | o1 | Térreo | QD - TER 1 | Identificação_Elemento - Descrição: ARANDELA 60W; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA DE EMBUTIR ARANDELA: 100 cm; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
 | Térreo | 7 | 4.75 | 10.85 | Alta | 100 | 1311 | 15 | A1 (Direta) | Sim | ARANDELA - 15 W (parede) | 4 - ILUMINAÇÃO - BANHEIROS | a1 | Térreo | QD - TER 1 | Identificação_Elemento - Descrição: ARANDELA 15W; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA DE EMBUTIR ARANDELA: 100 cm; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
 | Térreo | 7 | 4.75 | 10.85 | Alta | 100 | 1311 | 15 | A1 (Direta) | Sim | ARANDELA - 15 W (parede) | 7 - ILUMINAÇÃO - CINEMA | p1 | Térreo | QD - TER 1 | Identificação_Elemento - Descrição: ARANDELA 15W; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA DE EMBUTIR ARANDELA: 100 cm; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
6 x  | Térreo | 11.7 | 11.7 | 13.1 | Piso | 50 | 280 | 6 | A1 (Direta) | Não | Luminária de Embutir no chão - 6W | 6 - ILUMINAÇÃO - PISO EXTERNA | l1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - INFRAESTRUTURA - CAIXAS PISO - CAIXA DE ALUMÍNIO 4x4" BAIXA P/ PISO - 1" CAIXA DE PASSAGEM EM PVC, FORNECIMENTO E INSTALAÇÃO.: 1
6 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 5 - ILUMINAÇÃO - CAFÉ | e1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
6 x  | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 5 - ILUMINAÇÃO - CAFÉ | f1 | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
2 x  | Térreo | 8 | 200 | 11 | Teto | 95 | 280 | 30 | A1 (Direta) | Sim | Trilho eletrificado - trilho 2,0m - 4 spots - 7W/spot | 5 - ILUMINAÇÃO - CAFÉ | h1 | Térreo | QD - TER 1 | Circuito - Circuito_2: 5 - ILUMINAÇÃO - CAFÉ; Comando_2: h1; Pavimento_do_circuito_2: Térreo; Quadro_2: QD - TER 1; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - INFRAESTRUTURA - CAIXAS DE SOBREPOR - CAIXA DE PASSAGEM DE SOBREPOR OCTOGONAL, EM PVC, DIMENSÕES 3x3". FORNECIMENTO E INSTALAÇÃO.: 1; .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - TRILHO ELETRIFICADO DE 2 METRO COM 4 SPOTS - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | Térreo | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 2 - ILUMINAÇÃO - CIRCULAÇÃO E SALAS 01 | k | Térreo | QD - TER 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
5 x  | PAV 1 | 40 | 15 | 15 | Teto | 90 | 2200 | 36 | C2 (Direta) | Sim | Luminária de Sobrepor Cabinete | 2 - ILUMINAÇÃO - SALA PAV 1 | m | PAV 1 | QD - PAV 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - CABINETE DE LED - LUMINÁRIA: 1
8 x  | PAV 1 | 7.5 | 10 | 15 | Alta | 90 | 700 | 60 | A2.1 (Direta) | Sim | LUMINÁRIA 12xLED DIRECIONÁVEL | 1 - ILUMINAÇÃO - CIRCULAÇÃO | g | PAV 1 | QD - PAV 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - INFRAESTRUTURA - CAIXAS DE SOBREPOR - CAIXA DE PASSAGEM DE SOBREPOR OCTOGONAL, EM PVC, DIMENSÕES 3x3". FORNECIMENTO E INSTALAÇÃO.: 1; .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED DIRECIONÁVEL 12XLED: 1
5 x  | PAV 1 | 330 | 3 | 3 | Teto | 75 | 1440 | 30 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 3.3 M - STM | 1 - ILUMINAÇÃO - CIRCULAÇÃO | e | PAV 1 | QD - PAV 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
4 x  | PAV 1 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 1 - ILUMINAÇÃO - CIRCULAÇÃO | k | PAV 1 | QD - PAV 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
5 x  | PAV 1 | 15 | 15 | 11 | Teto | 75 | 1440 | 14.4 | A1 (Direta) | Sim | Fitas Led - VERTICAL 2.30M | 1 - ILUMINAÇÃO - CIRCULAÇÃO | f | PAV 1 | QD - PAV 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA LED 0.5M DE COMPRIMENTO - 14.4W/M, - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | PAV 1 | 7 | 4.75 | 10.85 | Alta | 100 | 1311 | 60 | A1 (Direta) | Sim | ARANDELA - ESFERA 60 W | 6 - ILUMINAÇÃO - ESCADARIA | Nenhum | PAV 2 | QD - PAV 2 | Identificação_Elemento - Descrição: ARANDELA 60W; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA DE EMBUTIR ARANDELA: 100 cm; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
3 x  | PAV 1 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | PLAFON LED EMBUTIR 20X20 | 1 - ILUMINAÇÃO - CIRCULAÇÃO | j | PAV 1 | QD - PAV 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
2 x  | PAV 1 | 650 | 3 | 3 | Teto | 75 | 1440 | 55 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 6.5M | 1 - ILUMINAÇÃO - CIRCULAÇÃO | d | PAV 1 | QD - PAV 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
5 x  | PAV 1 | 40 | 15 | 15 | Teto | 90 | 2200 | 36 | C2 (Direta) | Sim | Luminária de Sobrepor Cabinete | 2 - ILUMINAÇÃO - SALA PAV 1 | l | PAV 1 | QD - PAV 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - CABINETE DE LED - LUMINÁRIA: 1
2 x  | PAV 1 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 1 - ILUMINAÇÃO - CIRCULAÇÃO | b | PAV 1 | QD - PAV 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | PAV 1 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 1 - ILUMINAÇÃO - CIRCULAÇÃO | c | PAV 1 | QD - PAV 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
 | PAV 1 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 1 - ILUMINAÇÃO - CIRCULAÇÃO | a | PAV 1 | QD - PAV 1 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
 | PAV 1 | 500 | 3 | 3 | Teto | 75 | 1440 | 40 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 5M- LAB | 1 - ILUMINAÇÃO - CIRCULAÇÃO | i | PAV 1 | QD - PAV 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
3 x  | PAV 1 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 1 - ILUMINAÇÃO - CIRCULAÇÃO | h | PAV 1 | QD - PAV 1 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
3 x  | PAV 1 | 7 | 4.75 | 10.85 | Alta | 100 | 1311 | 60 | A1 (Direta) | Sim | ARANDELA - ESFERA 60 W | 3 - ILUMINAÇÃO - EXTERNA | o | PAV 1 | QD - PAV 1 | Identificação_Elemento - Descrição: ARANDELA 60W; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA DE EMBUTIR ARANDELA: 100 cm; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
3 x  | PAV 1 | 7 | 4.75 | 10.85 | Alta | 100 | 1311 | 60 | A1 (Direta) | Sim | ARANDELA - ESFERA 60 W | 3 - ILUMINAÇÃO - EXTERNA | n | PAV 1 | QD - PAV 1 | Identificação_Elemento - Descrição: ARANDELA 60W; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA DE EMBUTIR ARANDELA: 100 cm; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
4 x  | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 2 - ILUMINAÇÃO - SALA FRONTAL | g | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
5 x  | PAV 2 | 7.5 | 10 | 15 | Alta | 90 | 700 | 20 | A2.1 (Direta) | Sim | Canhão de LED | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | d1 | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - CANHÃO DE LED DIRECIONÁVEL: 1
5 x  | PAV 2 | 7.5 | 10 | 15 | Alta | 90 | 700 | 20 | A2.1 (Direta) | Sim | Canhão de LED | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | c1 | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - CANHÃO DE LED DIRECIONÁVEL: 1
4 x  | PAV 2 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | a1 | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
4 x  | PAV 2 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | b1 | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
 | PAV 2 | 400 | 3 | 3 | Teto | 75 | 1440 | 36 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 4M - STD | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | z | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
4 x  | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | g1 | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | PAV 2 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 3 - ILUMINAÇÃO - CIRCULAÇÃO I E SALA DE PROJEÇÃO | n | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
9 x  | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 3 - ILUMINAÇÃO - CIRCULAÇÃO I E SALA DE PROJEÇÃO | p | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
2 x  | PAV 2 | 122 | 14 | 5 | Teto | 90 | 2200 | 56 | C2 (Direta) | Sim | Luminária de Sobrepor Retangular - 2x28W SC | 1 - ILUMINAÇÃO - SALA E BANHEIRO | b | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 2x28; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA LED TUBULAR 2X28W: 100 cm
2 x  | PAV 2 | 122 | 14 | 5 | Teto | 90 | 2200 | 56 | C2 (Direta) | Sim | Luminária de Sobrepor Retangular - 2x28W SC | 1 - ILUMINAÇÃO - SALA E BANHEIRO | a | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 2x28; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA LED TUBULAR 2X28W: 100 cm
2 x  | PAV 2 | 122 | 14 | 5 | Teto | 90 | 2200 | 56 | C2 (Direta) | Sim | Luminária de Sobrepor Retangular - 2x28W SC | 2 - ILUMINAÇÃO - SALA FRONTAL | m | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 2x28; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA LED TUBULAR 2X28W: 100 cm
2 x  | PAV 2 | 122 | 14 | 5 | Teto | 90 | 2200 | 56 | C2 (Direta) | Sim | Luminária de Sobrepor Retangular - 2x28W SC | 2 - ILUMINAÇÃO - SALA FRONTAL | l | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 2x28; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA LED TUBULAR 2X28W: 100 cm
2 x  | PAV 2 | 122 | 14 | 5 | Teto | 90 | 2200 | 56 | C2 (Direta) | Sim | Luminária de Sobrepor Retangular - 2x28W SC | 2 - ILUMINAÇÃO - SALA FRONTAL | k | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 2x28; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA LED TUBULAR 2X28W: 100 cm
2 x  | PAV 2 | 122 | 14 | 5 | Teto | 90 | 2200 | 56 | C2 (Direta) | Sim | Luminária de Sobrepor Retangular - 2x28W SC | 2 - ILUMINAÇÃO - SALA FRONTAL | j | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 2x28; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA LED TUBULAR 2X28W: 100 cm
2 x  | PAV 2 | 200 | 3 | 3 | Teto | 75 | 1440 | 20 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 2M -CIRC | 2 - ILUMINAÇÃO - SALA FRONTAL | h | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
3 x  | PAV 2 | 300 | 3 | 3 | Teto | 75 | 1440 | 27 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 3M -CIRC | 3 - ILUMINAÇÃO - CIRCULAÇÃO I E SALA DE PROJEÇÃO | o | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
 | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 2 - ILUMINAÇÃO - SALA FRONTAL | i | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | PAV 2 | 7 | 4.75 | 10.85 | Alta | 100 | 1311 | 60 | A1 (Direta) | Sim | ARANDELA - ESFERA 60 W | 6 - ILUMINAÇÃO - ESCADARIA | Nenhum | PAV 2 | QD - PAV 2 | Identificação_Elemento - Descrição: ARANDELA 60W; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA DE EMBUTIR ARANDELA: 100 cm; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
 | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | b1 | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
3 x  | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | t | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | PAV 2 | 400 | 3 | 3 | Teto | 75 | 1440 | 36 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 4M - STD | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | u | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
4 x  | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | v | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | PAV 2 | 600 | 3 | 3 | Teto | 75 | 1440 | 50 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 6M - STG | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | w | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
3 x  | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | r | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | PAV 2 | 400 | 3 | 3 | Teto | 75 | 1440 | 36 | A1 (Direta) | Sim | Fitas Led - HORIZONTAL 4M - STD | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | s | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FITA DE LED 9,6W/m: 1
 | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | Nenhum | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
7 x  | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 4 - IILUMINAÇÃO - LAB. E CIRCULAÇÃO | q | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | a1 | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
 | PAV 2 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | f1 | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
3 x  | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | y | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
3 x  | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | x | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
5 x  | PAV 2 | 6.3 | 6.3 | 8.1 | Teto | 92 | 80 | 20 | A1 (Direta) | Sim | Luminária de Embutir - Par 20 Duplo Focal - 20W sc | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | e1 | PAV 2 | QD - PAV 2 | AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA DE LED PAR 20 DUPLO FOCAL DE EMBUTIR - MODELO E ESPECIFICAÇÕES VERIFICAR NO PROJETO LUMINOTÉCNICO: 1
3 x  | PAV 2 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 1 - ILUMINAÇÃO - SALA E BANHEIRO | f | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
2 x  | PAV 2 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 1 - ILUMINAÇÃO - SALA E BANHEIRO | e | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
3 x  | PAV 2 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 1 - ILUMINAÇÃO - SALA E BANHEIRO | d | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
3 x  | PAV 2 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 1 - ILUMINAÇÃO - SALA E BANHEIRO | c | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
 | PAV 2 | 20 | 20 | 5 | Teto | 92 | 1350 | 15 | A3 (Direta) | Sim | Plafon Quadrado com Painel de LED - 20x20cm 15W | 5 - ILUMINAÇÃO - SALA ESTUDIO E LAB. | h1 | PAV 2 | QD - PAV 2 | AltoQi_Builder - Indicação: 20x20; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - LUMINÁRIA PLAFONIER QUADRADO COM PAINEL DE LED - 20X20CM: 1
3 x  | CAIXA D AGUA | 7 | 4.75 | 10.85 | Alta | 100 | 1311 | 15 | A1 (Direta) | Sim | ARANDELA - 15 W (parede) | 41 - ILUMINAÇÃO - MANUTENÇÃO | a | CAIXA D AGUA | QD - B1 | Identificação_Elemento - Descrição: ARANDELA 15W; AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - LUMINÁRIAS - LUMINÁRIAS - FORNECIMENTO E INSTALAÇÃO - LUMINÁRIA DE EMBUTIR ARANDELA: 100 cm; Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1

# IfcBuildingElementProxy: Ponto de força
In: CAIXA D AGUA
AltoQi_Builder - Comprimento: 2.5 cm; Largura: 2.5 cm; Profundidade: 2.5 cm; Indicação: BPRE; Posição: Baixa
AltoQi_Builder-Ponto1 - Fator de potência (%): 72; Potência (W): 375; Quantidade: 1; Rendimento (%): 56; Tipo de ponto: Tomada 2P+T; Requer aterramento: Sim
Identificação_Elemento - Aplicação: Caixa; Descrição: Ponto 2P+T a 0,30m do piso; Nome: Bomba pressurização - 1/2cv monofásico; Classe: .BIMFLIX - TEMPLATE ELÉTRICA; Tipo: Ponto de força; Rede: Elétrica
Circuito - Circuito_1: 40 - PRESSURIZADOR; Comando_1: Nenhum; Pavimento_do_circuito_1: CAIXA D AGUA; Quadro_1: QD - B1
Pset_BuildingElementProxyTypeCommon - Reference: Ponto de força
AltoQi_QiBuilder-Itens_Associados - .BIMFLIX - DISPOSITIVO ELÉTRICO - PLACA EM PVC 2x4" - PLACA 4x2" EM PVC COM FURO, FORNECIMENTO E INSTALAÇÃO: 1; .BIMFLIX - INFRAESTRUTURA - CAIXAS DE EMBUTIR - CAIXA DE PASSAGEM DE EMBUTIR, PVC, DIMENSÕES 4x2". FORNECIMENTO E INSTALAÇÃO.: 1

# IfcCableCarrierFitting: Saída dupla para eletroduto (2)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Teto
Identificação_Elemento - Aplicação: Conexão; Descrição: Saída dupla para eletroduto; Nome: 38x38 mm; Classe: Perfilados lisos; Tipo: Saída dupla para eletroduto; Rede: Cabeamento
Pset_CableCarrierFittingTypeCommon - Reference: Saída dupla para eletroduto
AltoQi_QiBuilder-Itens_Associados - Acessórios Perfilados Lisos - Acessórios para Perfilados - Saída dupla para eletroduto: 1
Name | In
 | Térreo
 | PAV 2

# IfcCableCarrierFitting: Saída horizontal para eletroduto (7)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Teto
Identificação_Elemento - Aplicação: Conexão; Descrição: Saída horizontal para eletroduto; Nome: 38x38 mm; Classe: Perfilados lisos; Tipo: Saída horizontal para eletroduto; Rede: Cabeamento
Pset_CableCarrierFittingTypeCommon - Reference: Saída horizontal para eletroduto
AltoQi_QiBuilder-Itens_Associados - Acessórios Perfilados Lisos - Acessórios para Perfilados - Saída horizontal para eletroduto: 1
Name | In
2 x  | Térreo
5 x  | PAV 2

# IfcCableCarrierFitting: Terminal (7)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: TM; Posição: Teto
Identificação_Elemento - Aplicação: Conexão; Descrição: Terminal - 38x38mm; Nome: 38x38mm; Classe: Perfilados lisos; Tipo: Terminal; Rede: Cabeamento
Pset_CableCarrierFittingTypeCommon - Reference: Terminal
AltoQi_QiBuilder-Itens_Associados - Acessórios Perfilados Lisos - Tala plana perfurada - 38mm: 6; Acessórios Perfilados Lisos - Terminal - 38x38mm: 1; Acessórios uso geral - Arruela lisa galvan. - 1/4": 24; Acessórios uso geral - Parafuso galvan. cabeça lentilha - 1/4"x5/8" máquina rosca total: 24; Acessórios uso geral - Porca sextavada galvan. - 1/4": 24
Name | In
2 x  | Térreo
 | PAV 1
4 x  | PAV 2

# IfcCableCarrierSegment: Eletroduto c/ braçadeira PVC (11)
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm; Diâmetro interno: 2.13 cm; Diâmetro: ø3/4"; Espessura: 0.23 cm; Indicação: ø3/4"
Identificação_Elemento - Nome: 3/4"; Classe: Eletroduto PVC rosca; Tipo: Eletroduto c/ braçadeira PVC; Rede: Elétrica; Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto c/ braçadeira PVC
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 300 cm
Name | In | Comprimento (cm) = Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4" (cm) | Acessórios p/ eletrodutos - Luva PVC rosca - 3/4" = Acessórios uso geral - Bucha de nylon - S4 = Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante = Eletroduto PVC rosca - Braçadeira PVC encaixe - 3/4" | Cabo Unipolar - cobre - Isol.PVC - 450/750V - 2.5 mm² (cm)
EL565 | Térreo | 443 | 5 | 886
EL566 | Térreo | 404 | 4 | 808
EL567 | Térreo | 494 | 5 | 988
EL568 | Térreo | 398 | 4 | 796
EL569 | Térreo | 194 | 2 | 388
EL569 | Térreo | 352 | 4 | 704
EL583 | Térreo | 50 | 1 | 150
EL585 | Térreo | 60 | 1 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 180 cm
EL586 | Térreo | 320 | 4 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 960 cm
EL270 | PAV 1 | 641.8 | 7 | 1283.6
EL9 | CAIXA D AGUA | 100 | 1 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 300 cm

# IfcCableCarrierSegment: Eletroduto c/ braçadeira cunha (83)
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm
Identificação_Elemento - Classe: Eletroduto PVC rosca; Tipo: Eletroduto c/ braçadeira cunha; Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto c/ braçadeira cunha
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 300 cm
Name | In | Diâmetro interno (cm) | Diâmetro = Indicação | Espessura (cm) | Comprimento (cm) | Nome | Rede | Acessórios uso geral - Bucha de nylon - S6 = Acessórios uso geral - Parafuso fenda galvan. cab. panela - 4,2x32mm autoatarrachante | Cabo Unipolar - cobre - Isol.PVC - 450/750V - 2.5 mm² (cm)
EL388 | Térreo | 7.96 | ø3" | 0.4 | 230 | 3" | Elétrica (QD) | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S8: 3; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 6,3x50mm autoatarrachante: 3; Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 150 mm²: 920 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3": 230 cm
EL399 | Térreo | 2.75 | ø1" | 0.27 | 223 | 1" | Elétrica (QD) | 5 | 2230 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1115 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 669 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1": 5; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1": 446 cm
EL400 | Térreo | 3.61 | ø1 1/4" | 0.29 | 753 | 1.1/4" | Elétrica (QD) | 15 | 7530 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 3765 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 6777 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 4; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 15; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 1506 cm
EL401 | Térreo | 2.75 | ø1" | 0.27 | 1476 | 1" | Elétrica (QD) | 30 | 8856 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 7380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 10332 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1": 30; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1": 2952 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1": 8
EL401 | Térreo | 3.61 | ø1 1/4" | 0.29 | 936 | 1.1/4" | Elétrica (QD) | 19 | 5616 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 4680 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 8424 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 6; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 19; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 1872 cm
EL411 | Térreo | 2.75 | ø1" | 0.27 | 223 | 1" | Elétrica (QD) | 5 | 2007 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1": 5; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1": 446 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 10 mm²: 1115 cm
EL412 | Térreo | 3.61 | ø1 1/4" | 0.29 | 290 | 1.1/4" | Elétrica (QD) | 6 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 4350 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 6; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 580 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 10 mm²: 1450 cm
EL414 | Térreo | 4.14 | ø1 1/2" | 0.3 | 355 | 1.1/2" | Elétrica (QD) | 8 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 5325 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 10 mm²: 1775 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/2": 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/2": 8; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/2": 710 cm
EL465 | Térreo | 2.13 | ø3/4" | 0.23 | 165 | 3/4" | Elétrica |  | 495 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 165 cm
EL466 | Térreo | 2.13 | ø3/4" | 0.23 | 165 | 3/4" | Elétrica |  | 495 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 165 cm
EL467 | Térreo | 2.13 | ø3/4" | 0.23 | 165 | 3/4" | Elétrica |  | 495 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 165 cm
EL468 | Térreo | 2.13 | ø3/4" | 0.23 | 166 | 3/4" | Elétrica |  | 498 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 166 cm
EL469 | Térreo | 2.13 | ø3/4" | 0.23 | 163 | 3/4" | Elétrica |  | 489 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 163 cm
EL470 | Térreo | 2.13 | ø3/4" | 0.23 | 167 | 3/4" | Elétrica |  | 501 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 167 cm
EL471 | Térreo | 2.13 | ø3/4" | 0.23 | 165 | 3/4" | Elétrica |  | 495 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 165 cm
EL472 | Térreo | 2.13 | ø3/4" | 0.23 | 165 | 3/4" | Elétrica |  | 495 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 165 cm
EL473 | Térreo | 2.13 | ø3/4" | 0.23 | 164 | 3/4" | Elétrica |  | 492 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 164 cm
EL474 | Térreo | 2.13 | ø3/4" | 0.23 | 146 | 3/4" | Elétrica |  | 438 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 146 cm
EL489 | Térreo | 2.13 | ø3/4" | 0.23 | 428 | 3/4" | Elétrica |  | 1284 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 5; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 5; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 5; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 428 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 3/4": 1
EL490 | Térreo | 2.13 | ø3/4" | 0.23 | 164 | 3/4" | Elétrica |  | 492 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 164 cm
EL491 | Térreo | 2.13 | ø3/4" | 0.23 | 146 | 3/4" | Elétrica |  | 438 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 146 cm
EL493 | Térreo | 2.13 | ø3/4" | 0.23 | 167 | 3/4" | Elétrica |  | 501 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 167 cm
EL494 | Térreo | 2.13 | ø3/4" | 0.23 | 165 | 3/4" | Elétrica |  | 495 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 165 cm
EL495 | Térreo | 2.13 | ø3/4" | 0.23 | 165 | 3/4" | Elétrica |  | 495 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 165 cm
EL497 | Térreo | 2.13 | ø3/4" | 0.23 | 166 | 3/4" | Elétrica |  | 498 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 166 cm
EL498 | Térreo | 2.13 | ø3/4" | 0.23 | 163 | 3/4" | Elétrica |  | 489 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 163 cm
EL499 | Térreo | 2.13 | ø3/4" | 0.23 | 165 | 3/4" | Elétrica |  | 495 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 165 cm
EL501 | Térreo | 2.13 | ø3/4" | 0.23 | 165 | 3/4" | Elétrica |  | 495 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 165 cm
EL502 | Térreo | 2.13 | ø3/4" | 0.23 | 165 | 3/4" | Elétrica |  | 495 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 165 cm
EL504 | Térreo | 2.13 | ø3/4" | 0.23 | 418 | 3/4" | Elétrica |  | 1254 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 5; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 5; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 5; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 418 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 3/4": 1
EL518 | Térreo | 2.75 | ø1" | 0.27 | 386 | 1" | Elétrica (QD) | 4 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1930 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1": 4; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1": 386 cm
EL519 | Térreo | 2.13 | ø3/4" | 0.23 | 140 | 3/4" | Elétrica |  | 560 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 140 cm
EL603 | Térreo | 3.61 | ø1 1/4" | 0.29 | 30 | 1.1/4" | Elétrica (ARC) | 1 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 210 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 1; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 30 cm
EL604 | Térreo | 3.61 | ø1 1/4" | 0.29 | 810 | 1.1/4" | Elétrica (QD) | 17 | 6480 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 5670 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 4; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 17; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 1620 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 10 mm²: 4050 cm
EL605 | Térreo | 2.13 | ø3/4" | 0.23 | 335 | 3/4" | Elétrica |  | 670 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 4; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 4; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 4; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 335 cm
CE17 | PAV 1 | 2.13 | ø3/4" | 0.23 | 360 | 3/4" | Cabeamento | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 4; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 4; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 4; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 360 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 3/4": 1
EL193 | PAV 1 | 4.14 | ø1 1/2" | 0.3 | 380 | 1.1/2" | Elétrica (QD) | 8 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 6460 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 10 mm²: 1900 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/2": 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/2": 8; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/2": 760 cm
EL206 | PAV 1 | 3.61 | ø1 1/4" | 0.29 | 240 | 1.1/4" | Elétrica (QD) | 3 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 2160 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 240 cm
EL206 | PAV 1 | 3.61 | ø1 1/4" | 0.29 | 360 | 1.1/4" | Elétrica (QD) | 4 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1800 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 3960 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 1; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 4; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 360 cm
EL206 | PAV 1 | 3.61 | ø1 1/4" | 0.29 | 420 | 1.1/4" | Elétrica (QD) | 5 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 2100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 3780 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 1; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 5; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 420 cm
EL206 | PAV 1 | 3.61 | ø1 1/4" | 0.29 | 300 | 1.1/4" | Elétrica (QD) | 3 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1500 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 3900 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 300 cm
EL208 | PAV 1 | 3.61 | ø1 1/4" | 0.29 | 710 | 1.1/4" | Elétrica (QD) | 8 | 2840 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 3550 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 8; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 710 cm
EL239 | PAV 1 | 3.61 | ø1 1/4" | 0.29 | 390 | 1.1/4" | Elétrica (QD) | 4 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 1; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 4; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 390 cm
EL240 | PAV 1 | 3.61 | ø1 1/4" | 0.29 | 306 | 1.1/4" | Elétrica (QD) | 3 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1530 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 3978 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 306 cm
EL271 | PAV 1 | 3.61 | ø1 1/4" | 0.29 | 690 | 1.1/4" | Elétrica (QD) | 7 | 2760 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 4830 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 7; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 690 cm
EL271 | PAV 1 | 3.61 | ø1 1/4" | 0.29 | 500 | 1.1/4" | Elétrica (QD) | 5 | 2000 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 4500 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 1; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 5; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 500 cm
CE62 | PAV 2 | 2.13 | ø3/4" | 0.23 | 470 | 3/4" | Cabeamento | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 5; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 5; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 5; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 470 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 3/4": 1
EL1 | PAV 2 | 4.14 | ø1 1/2" | 0.3 | 420 | 1.1/2" | Elétrica (QD) | 9 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/2": 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/2": 9; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/2": 840 cm
