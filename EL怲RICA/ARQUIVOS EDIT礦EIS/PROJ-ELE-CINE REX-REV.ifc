Properties of the parts of a building model (IFC4), part 2 of 5

# IfcCableCarrierSegment: Eletroduto c/ braçadeira cunha (83)
Name | In | Diâmetro interno (cm) | Diâmetro = Indicação | Espessura (cm) | Comprimento (cm) | Nome | Rede | Acessórios uso geral - Bucha de nylon - S6 = Acessórios uso geral - Parafuso fenda galvan. cab. panela - 4,2x32mm autoatarrachante | Cabo Unipolar - cobre - Isol.PVC - 450/750V - 2.5 mm² (cm)
EL174 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 264 | 1.1/4" | Elétrica (QD) | 3 | 5016 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 264 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 1.5 mm²: 528 cm
EL175 | PAV 2 | 2.75 | ø1" | 0.27 | 476 | 1" | Elétrica (QD) | 10 | 6664 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 7140 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1": 10; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1": 952 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1": 2; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 1.5 mm²: 952 cm
EL185 | PAV 2 | 2.75 | ø1" | 0.27 | 250 | 1" | Elétrica (QD) | 3 | 2000 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 2250 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1": 250 cm
EL186 | PAV 2 | 2.13 | ø3/4" | 0.23 | 310 | 3/4" | Elétrica |  | 1550 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 4; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 4; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 4; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 310 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 3/4": 1
EL2 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 420 | 1.1/4" | Elétrica (QD) | 5 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 1; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 5; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 420 cm
EL202 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 1098 | 1.1/4" | Elétrica (QD) | 11 | 13176 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 14274 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 3; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 11; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 1098 cm
EL202 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 231 | 1.1/4" | Elétrica (QD) | 3 | 2772 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 2541 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 231 cm
EL203 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 670 | 1.1/4" | Elétrica (QD) | 7 | 10050 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 8710 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 7; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 670 cm
EL203 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 648 | 1.1/4" | Elétrica (QD) | 7 | 9720 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 9720 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 7; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 648 cm
EL3 | PAV 2 | 4.14 | ø1 1/2" | 0.3 | 420 | 1.1/2" | Elétrica (QD) | 5 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/2": 1; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/2": 5; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/2": 420 cm
EL300 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 30 | 1.1/4" | Elétrica (ARC) | 1 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 450 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 1; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 30 cm
EL302 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 472 | 1.1/4" | Elétrica | 10 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 2360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 8024 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 10; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 944 cm
EL308 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 890 | 1.1/4" | Elétrica (QD) | 18 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 4450 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 15130 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 4; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 18; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 1780 cm
EL31 | PAV 2 | 2.13 | ø3/4" | 0.23 | 221 | 3/4" | Elétrica |  | 1105 | AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 3; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 3; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 221 cm
EL5 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 365 | 1.1/4" | Elétrica (QD) | 8 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1825 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 6935 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 8; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 730 cm
EL52 | PAV 2 | 2.75 | ø1" | 0.27 | 1300.6 | 1" | Elétrica (QD) | 13 | 5202.4 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 6503 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1": 13; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1": 1300.6 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1": 4
EL6 | PAV 2 | 3.61 | ø1 1/4" | 0.29 | 120 | 1.1/4" | Elétrica (QD) | 3 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 2040 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 240 cm
EL1 | CAIXA D AGUA | 4.14 | ø1 1/2" | 0.3 | 80 | 1.1/2" | Elétrica (QD) | 2 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 150 mm²: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 800 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 3760 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 10 mm²: 400 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/2": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/2": 160 cm; Cabo Unipolar - cobre - Isol. XLPE - 0,6/1kV - 70 mm²: 80 cm
EL10 | CAIXA D AGUA | 5.28 | ø2" | 0.31 | 2235.98 | 2" | Elétrica (QD) | 23 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 11179.9 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1": 7; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 2": 23; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 2": 2235.97 cm
EL10 | CAIXA D AGUA | 5.28 | ø2" | 0.31 | 1320 | 2" | Elétrica (QD) | 14 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 6600 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1": 4; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 2": 14; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 2": 1320 cm
EL2 | CAIXA D AGUA | 4.14 | ø1 1/2" | 0.3 | 80 | 1.1/2" | Elétrica (QD) | 1 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/2": 1; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/2": 80 cm
EL3 | CAIXA D AGUA | 3.61 | ø1 1/4" | 0.29 | 80 | 1.1/4" | Elétrica (QD) | 1 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 1; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 80 cm
EL30 | CAIXA D AGUA | 5.28 | ø2" | 0.31 | 360 | 2" | Elétrica (ARC) | 8 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Luva PVC rosca - 1": 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 2": 8; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 2": 720 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 6 mm²: 1440 cm
EL32 | CAIXA D AGUA | 6.71 | ø2 1/2" | 0.38 | 380 | 2.1/2" | Elétrica (QD) | 8 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1900 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 7220 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 2.1/2": 2; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 50 mm²: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 95 mm²: 1520 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 2.1/2": 8; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 2.1/2": 760 cm
EL35 | CAIXA D AGUA | 6.71 | ø2 1/2" | 0.38 | 257.72 | 2.1/2" | Elétrica (ARC) | 6 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1288.62 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 12113.1 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 50 mm²: 257.725 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 95 mm²: 1030.9 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 2.1/2": 6; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 2.1/2": 515.45 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 16 mm²: 1288.62 cm
EL36 | CAIXA D AGUA | 3.61 | ø1 1/4" | 0.29 | 40 | 1.1/4" | Elétrica (ARC) | 1 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1160 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 1; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 80 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 16 mm²: 200 cm
EL38 | CAIXA D AGUA | 4.14 | ø1 1/2" | 0.3 | 160 | 1.1/2" | Elétrica (ARC) | 4 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/2": 4; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/2": 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 10 mm²: 1600 cm
EL39 | CAIXA D AGUA | 4.14 | ø1 1/2" | 0.3 | 160 | 1.1/2" | Elétrica (ARC) | 4 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/2": 4; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/2": 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 10 mm²: 2080 cm
EL4 | CAIXA D AGUA | 4.14 | ø1 1/2" | 0.3 | 80 | 1.1/2" | Elétrica (QD) | 2 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/2": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/2": 160 cm
EL41 | CAIXA D AGUA | 3.61 | ø1 1/4" | 0.29 | 280 | 1.1/4" | Elétrica (ARC) | 3 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 10 mm²: 1120 cm
EL42 | CAIXA D AGUA | 6.71 | ø2 1/2" | 0.38 | 40 | 2.1/2" | Elétrica (ARC) | 1 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 720 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 6 mm²: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 50 mm²: 40 cm; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 95 mm²: 160 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 2.1/2": 1; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 2.1/2": 80 cm
EL46 | CAIXA D AGUA | 3.61 | ø1 1/4" | 0.29 | 940 | 1.1/4" | Elétrica (QD) | 10 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 4700 cm; Acessórios p/ eletrodutos - Luva PVC rosca - 1.1/4": 3; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1.1/4": 10; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 940 cm
EL47 | CAIXA D AGUA | 2.75 | ø1" | 0.27 | 80 | 1" | Elétrica | 1 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 320 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 1": 1; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1": 80 cm
EL5 | CAIXA D AGUA | 2.13 | ø3/4" | 0.23 | 200 | 3/4" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1200 cm; Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 200 cm
EL6 | CAIXA D AGUA | 2.13 | ø3/4" | 0.23 | 149.02 | 3/4" | Elétrica | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1341.22 cm; Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Eletroduto PVC rosca - Braçadeira galvan. tipo cunha - 3/4": 2; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 3/4": 149.025 cm

# IfcCableCarrierSegment: Eletroduto c/ braçadeira unha, EL173
In: PAV 2
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm; Diâmetro interno: 3.61 cm; Diâmetro: ø1 1/4"; Espessura: 0.29 cm; Indicação: ø1 1/4"; Comprimento: 264 cm
Identificação_Elemento - Nome: 1.1/4"; Classe: Eletroduto PVC rosca; Tipo: Eletroduto c/ braçadeira unha; Rede: Elétrica (QD); Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto c/ braçadeira unha
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 300 cm
AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S6: 3; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 4,2x32mm autoatarrachante: 3; Cabo Unipolar - cobre - Isol.PVC - 0,6/1kV - 6 mm²: 1320 cm; Eletroduto PVC rosca - Braçadeira galvan. tipo unha - 1.1/4": 3; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1.1/4": 264 cm

# IfcCableCarrierSegment: Eletroduto tipo leve (609)
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 100 cm
Identificação_Elemento - Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo leve; Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto tipo leve
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 100 cm
Name | In | Diâmetro interno (cm) | Diâmetro | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Rede | Eletroduto PVC flexível - Eletroduto leve - 3/4" (cm) | Cabo Unipolar - cobre - Isol.PVC - 450/750V - 2.5 mm² (cm)
CE1 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Cabeamento | 120 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 360 cm
CE10 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Cabeamento | 100 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 100 cm
CE11 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 90 | 3/4" | Cabeamento | 90 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 90 cm
CE12 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 90 | 3/4" | Cabeamento | 90 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 180 cm
CE13 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Cabeamento | 130 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 130 cm
CE14 | Térreo | 2.56 | ø1" | 0.32 | ø1" | 243.92 | 1" | Cabeamento | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 1219.61 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 243.923 cm
CE15 | Térreo | 2.56 | ø1" | 0.32 | ø1" | 354.34 | 1" | Cabeamento | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 1771.71 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 354.343 cm
CE15 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 269.58 | 3/4" | Cabeamento | 269.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 269.58 cm
CE17 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 764.34 | 3/4" | Cabeamento | 764.343
CE2 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 90 | 3/4" | Cabeamento | 90 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 180 cm
CE21 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 509.58 | 3/4" | Cabeamento | 509.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 509.58 cm
CE23 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 419.58 | 3/4" | Cabeamento | 419.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 419.58 cm
CE24 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 419.58 | 3/4" | Cabeamento | 419.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 1678.32 cm
CE25 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200.43 | 3/4" | Cabeamento | 200.43 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 200.43 cm
CE26 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 170.43 | 3/4" | Cabeamento | 170.43 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 170.43 cm
CE28 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 619.58 | 3/4" | Cabeamento | 619.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 619.58 cm
CE29 | Térreo | 2.56 | ø1" | 0.32 | ø1" | 34.34 | 1" | Cabeamento | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 549.48 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 68.685 cm
CE3 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Cabeamento | 110 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 110 cm
CE30 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 699.57 | 3/4" | Cabeamento | 699.57 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 2098.71 cm
CE31 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Cabeamento | 130 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 260 cm
CE32 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 250.42 | 3/4" | Cabeamento | 250.42 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 1001.68 cm
CE33 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 770.84 | 3/4" | Cabeamento | 770.84 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 1541.68 cm
CE34 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 289.58 | 3/4" | Cabeamento | 289.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 289.58 cm
CE35 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 339.58 | 3/4" | Cabeamento | 339.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 1018.74 cm
CE4 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 90 | 3/4" | Cabeamento | 90 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 360 cm
CE5 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 90 | 3/4" | Cabeamento | 90 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 270 cm
CE6 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Cabeamento | 110 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 220 cm
CE7 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Cabeamento | 100 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 100 cm
CE9 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Cabeamento | 120 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 120 cm
EL10 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL11 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL110 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL115 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 550
EL116 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 550
EL117 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 550
EL169 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 800
EL171 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 1380
EL176 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 1680
EL183 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 240 | 3/4" | Elétrica | 240 | 480
EL184 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 419 | 3/4" | Elétrica | 419 | 838
EL186 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 389 | 3/4" | Elétrica | 389 | 778
EL195 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 480
EL196 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL197 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 760
EL198 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL199 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 170 | 3/4" | Elétrica | 170 | 510
EL204 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330
EL216 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 202 | 3/4" | Elétrica | 202 | 606
EL217 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 202 | 3/4" | Elétrica | 202 | 606
EL223 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 900
EL224 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL225 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL226 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL232 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 750
EL233 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 750
EL234 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 750
EL236 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 800
EL237 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 560
EL238 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 420
EL239 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL240 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL241 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL242 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL243 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL244 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL260 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 400 | 3/4" | Elétrica | 400 | 2800
EL261 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 320 | 3/4" | Elétrica | 320 | 1920
EL262 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 780
EL264 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 400 | 3/4" | Elétrica | 400 | 2400
EL265 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 410 | 3/4" | Elétrica | 410 | 2460
EL266 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 410 | 3/4" | Elétrica | 410 | 1640
EL267 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 400 | 3/4" | Elétrica | 400 | 1600
EL269 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 400 | 3/4" | Elétrica | 400 | 2000
EL270 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 780
EL271 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 780
EL272 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 780
EL280 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 960
EL281 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 170 | 3/4" | Elétrica | 170 | 850
EL282 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 480
EL283 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330
EL284 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330
EL285 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330
EL286 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 379 | 3/4" | Elétrica | 379 | 1137
EL287 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 180 | 3/4" | Elétrica | 180 | 540
EL3 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL31 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL315 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 300
EL316 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 90 | 3/4" | Elétrica | 90 | 270
EL317 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL318 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 600
EL319 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 80 | 3/4" | Elétrica | 80 | 320
EL320 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 90 | 3/4" | Elétrica | 90 | 360
EL321 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 520
EL322 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 1120
EL323 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 180 | 3/4" | Elétrica | 180 | 1260
EL324 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL325 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL326 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL327 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 420
EL328 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 330 | 3/4" | Elétrica | 330 | 1650
EL329 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 480
EL330 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 950
EL331 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 910
EL332 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL333 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 480
EL334 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 374 | 3/4" | Elétrica | 374 | 1122
EL335 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 170 | 3/4" | Elétrica | 170 | 510
EL336 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 276 | 3/4" | Elétrica | 276 | 828
EL337 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 266 | 3/4" | Elétrica | 266 | 798
EL338 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 180 | 3/4" | Elétrica | 180 | 540
EL339 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 1150
EL34 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL340 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 300
EL341 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 300
EL342 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330
EL343 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL344 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL345 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL347 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 300
EL348 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 330
EL350 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL351 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 339 | 3/4" | Elétrica | 339 | 1017
EL352 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 950
EL353 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 379 | 3/4" | Elétrica | 379 | 1137
EL354 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 349 | 3/4" | Elétrica | 349 | 1047
EL355 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 349 | 3/4" | Elétrica | 349 | 1047
EL356 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL357 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 1150
EL358 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1000
EL359 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1000
EL360 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1000
EL361 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1000
EL363 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 920
EL364 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1200
EL365 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1600
EL366 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1600
EL367 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1000
EL37 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL373 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 690
EL374 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 240 | 3/4" | Elétrica | 240 | 720
EL375 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 146 | 3/4" | Elétrica | 146 | 438
EL376 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 129 | 3/4" | Elétrica | 129 | 387
EL38 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL39 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL403 | Térreo | 2.56 | ø1" | 0.32 | ø1" | 352 | 1" | Elétrica (QD) |  | 1760 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 352 cm
EL404 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 180 | 3/4" | Elétrica | 180 | 540
EL405 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 290 | 3/4" | Elétrica | 290 | 1160
EL406 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 750
EL407 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 170 | 3/4" | Elétrica | 170 | 680
EL415 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 199 | 3/4" | Elétrica | 199 | 1393
EL416 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 291 | 3/4" | Elétrica | 291 | 1455
EL417 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 216 | 3/4" | Elétrica | 216 | 648
EL42 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL420 | Térreo | 2.56 | ø1" | 0.32 | ø1" | 215 | 1" | Elétrica (QD) |  | 1720 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 215 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1505 cm
EL420 | Térreo | 2.56 | ø1" | 0.32 | ø1" | 300 | 1" | Elétrica (QD) |  | 1800 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1500 cm
EL420 | Térreo | 2.56 | ø1" | 0.32 | ø1" | 1100 | 1" | Elétrica (QD) |  | 6600 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 1100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 5500 cm
EL421 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 46 | 3/4" | Elétrica | 46 | 184
EL422 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 70 | 3/4" | Elétrica | 70 | 560
EL423 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 1380
EL424 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 507 | 3/4" | Elétrica | 507 | 3042
EL425 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 440
EL429 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 270 | 3/4" | Elétrica | 270 | 540
EL430 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 349 | 3/4" | Elétrica | 349 | 2094
EL432 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 196 | 3/4" | Elétrica | 196 | 980
EL433 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 60 | 3/4" | Elétrica | 60 | 180
EL434 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 90 | 3/4" | Elétrica | 90 | 270
EL435 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL436 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 950
EL437 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 379 | 3/4" | Elétrica | 379 | 1137
EL438 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 309 | 3/4" | Elétrica | 309 | 1854
EL443 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 180 | 3/4" | Elétrica | 180 | 540
EL444 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 700 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 420 cm
EL447 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 600 cm
EL449 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 90 | 3/4" | Elétrica | 90 | 270
EL45 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL450 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 300 | 3/4" | Elétrica | 300 | 900
EL451 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 1150
EL452 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 290 | 3/4" | Elétrica | 290 | 870
EL453 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL454 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 300
EL455 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 300
EL456 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 30 | 3/4" | Elétrica | 30 | 90
EL457 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 60 | 3/4" | Elétrica | 60 | 180
EL458 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 307 | 3/4" | Elétrica | 307 | 921
EL459 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 50 | 3/4" | Elétrica | 50 | 150
EL460 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 60 | 3/4" | Elétrica | 60 | 180
EL461 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 379 | 3/4" | Elétrica | 379 | 1137
EL462 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 40 | 3/4" | Elétrica | 40 | 120
EL463 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 200 | 400 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 300 cm
EL464 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 347 | 3/4" | Elétrica | 347 | 694 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1041 cm
EL48 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL49 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL50 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL506 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 1411 | 3/4" | Elétrica | 1411 | 7055
EL507 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 280 | 3/4" | Elétrica | 280 | 1680
EL508 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 270 | 3/4" | Elétrica | 270 | 1620
EL509 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 430 | 3/4" | Elétrica | 430 | 2580
EL510 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 280 | 3/4" | Elétrica | 280 | 1960
EL511 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 340 | 3/4" | Elétrica | 340 | 2380
EL512 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 398 | 3/4" | Elétrica | 398 | 1990
EL513 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 40 | 3/4" | Elétrica | 40 | 160
EL517 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 300 | 3/4" | Elétrica | 300 | 900
EL520 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 203 | 3/4" | Elétrica | 203 | 609
EL521 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 294 | 3/4" | Elétrica | 294 | 588
EL522 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 502 | 3/4" | Elétrica | 502 | 2510
EL523 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 300
EL526 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL528 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 262 | 3/4" | Elétrica | 262 | 524
EL529 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 332 | 3/4" | Elétrica | 332 | 996
EL53 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1200
EL530 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 50 | 3/4" | Elétrica | 50 | 150
EL531 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 20 | 3/4" | Elétrica | 20 | 80
EL532 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 235 | 3/4" | Elétrica | 235 | 470
EL533 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 255 | 3/4" | Elétrica | 255 | 510
EL534 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 265 | 3/4" | Elétrica | 265 | 530
EL535 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 215 | 3/4" | Elétrica | 215 | 430
EL536 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 225 | 3/4" | Elétrica | 225 | 450
EL537 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 306 | 3/4" | Elétrica | 306 | 612
EL539 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 30 | 3/4" | Elétrica | 30 | 60
EL541 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 346 | 3/4" | Elétrica | 346 | 1038
EL542 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 389 | 3/4" | Elétrica | 389 | 778
EL543 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 226 | 3/4" | Elétrica | 226 | 452
EL545 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 252 | 3/4" | Elétrica | 252 | 504
EL547 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 300
EL548 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 259 | 3/4" | Elétrica | 259 | 1036
EL550 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 400 | 3/4" | Elétrica | 400 | 800 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1200 cm
EL551 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 320 | 3/4" | Elétrica | 320 | 640 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 960 cm
EL557 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 230 | 3/4" | Elétrica | 230 | 690
EL56 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1200
EL560 | Térreo | 2.56 | ø1" | 0.32 | ø1" | 180 | 1" | Elétrica |  | 900 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 540 cm
EL561 | Térreo | 2.56 | ø1" | 0.32 | ø1" | 340 | 1" | Elétrica |  | 1360 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1700 cm
EL562 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 237 | 3/4" | Elétrica | 237 | 474
EL563 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 231 | 3/4" | Elétrica | 231 | 693
EL587 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 80 | 3/4" | Elétrica | 80 | 400
EL588 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 268 | 3/4" | Elétrica | 268 | 1340
EL589 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 298 | 3/4" | Elétrica | 298 | 894
EL59 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 1260
EL590 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 220
EL591 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 215 | 3/4" | Elétrica | 215 | 645
EL592 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 245 | 3/4" | Elétrica | 245 | 490
EL595 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 640 | 3/4" | Elétrica (ARC) | 640 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1920 cm
EL596 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 755 | 3/4" | Elétrica (ARC) | 755 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 3775 cm
EL597 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 374 | 3/4" | Elétrica (ARC) | 374 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1122 cm
EL598 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 166 | 3/4" | Elétrica (ARC) | 166 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 498 cm
EL599 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 399 | 3/4" | Elétrica (ARC) | 399 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1197 cm
EL6 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL60 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1200
EL601 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 400 | 3/4" | Elétrica (ARC) | 400 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 1200 cm
EL606 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 187 | 3/4" | Elétrica | 187 | 374
EL607 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 111 | 3/4" | Elétrica | 111 | 333
EL608 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 277 | 3/4" | Elétrica (ARC) | 277 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 831 cm
EL609 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica (ARC) | 130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 390 cm
EL61 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 1260
EL610 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 880
EL611 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 305 | 3/4" | Elétrica | 305 | 2440
EL612 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 170 | 3/4" | Elétrica | 170 | 510
EL613 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 54 | 3/4" | Elétrica | 54 | 162
EL614 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200.5 | 3/4" | Elétrica | 200.5 | 802
EL615 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 452 | 3/4" | Elétrica | 452 | 3164
EL616 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Elétrica | 110 | 660
EL617 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 92 | 3/4" | Elétrica | 92 | 276
EL618 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 10 | 3/4" | Elétrica | 10 | 30
EL619 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 80 | 3/4" | Elétrica | 80 | 240
EL628 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 908 | 3/4" | Elétrica | 908 | 4540
EL629 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 339 | 3/4" | Elétrica | 339 | 1017
EL630 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 290 | 3/4" | Elétrica | 290 | 870
EL631 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 290 | 3/4" | Elétrica | 290 | 870
EL632 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 300 | 3/4" | Elétrica | 300 | 900
EL633 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 270 | 3/4" | Elétrica | 270 | 810
EL634 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 390 | 3/4" | Elétrica | 390 | 1170
EL637 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 290 | 3/4" | Elétrica | 290 | 870
EL638 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 290 | 3/4" | Elétrica | 290 | 870
EL64 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL640 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 300 | 3/4" | Elétrica | 300 | 900
EL641 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 270 | 3/4" | Elétrica | 270 | 810
EL644 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 390 | 3/4" | Elétrica | 390 | 1170
EL646 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 290 | 3/4" | Elétrica | 290 | 870
EL647 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 319 | 3/4" | Elétrica | 319 | 957
EL67 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL70 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL71 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL72 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL75 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL78 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL81 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL82 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 600
EL83 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 630
EL868 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 928 | 3/4" | Elétrica | 928 | 4640
EL9 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 200 | 3/4" | Elétrica | 200 | 1400
EL90 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 1050
EL91 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 1120
EL92 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Elétrica | 100 | 400
EL93 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 480
EL94 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica | 150 | 450
EL95 | Térreo | 1.94 | ø3/4" | 0.15 | ø3/4" | 170 | 3/4" | Elétrica | 170 | 510
CE1 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Cabeamento | 150 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 150 cm
CE12 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 555.58 | 3/4" | Cabeamento | 555.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 1666.74 cm
CE13 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 497.58 | 3/4" | Cabeamento | 497.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 995.16 cm
CE15 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 153.57 | 3/4" | Cabeamento | 153.57 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 153.57 cm
CE18 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 491.58 | 3/4" | Cabeamento | 491.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 983.16 cm
CE19 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 1340 | 3/4" | Cabeamento | 1340
CE2 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Cabeamento | 140 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 280 cm
CE20 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 390 | 3/4" | Cabeamento | 390
CE21 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 310.66 | 3/4" | Cabeamento | 310.657 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 2795.92 cm
CE22 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 513 | 3/4" | Cabeamento | 513 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 4104 cm
CE23 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 644.58 | 3/4" | Cabeamento | 644.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 644.58 cm
CE3 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Cabeamento | 140 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 140 cm
CE4 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Cabeamento | 110 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - Cabo UTP-6 - 24AWG - 4: 110 cm
EL102 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 420
EL103 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 420
EL104 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 560
EL105 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 170 | 3/4" | Elétrica | 170 | 850 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 510 cm
EL106 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 950 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 570 cm
EL107 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 480
EL108 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL110 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 307 | 3/4" | Elétrica | 307 | 921
EL127 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 499 | 3/4" | Elétrica | 499 | 1497
EL128 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 950
2 x EL172 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 170 | 3/4" | Elétrica | 170 | 510
EL173 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 330 | 3/4" | Elétrica | 330 | 1320 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 990 cm
EL174 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 750
EL175 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 750
EL176 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 750
EL177 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 250 | 3/4" | Elétrica | 250 | 750
EL179 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL180 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL181 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL182 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL183 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL184 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL185 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 152 | 3/4" | Elétrica | 152 | 608
EL190 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 290 | 3/4" | Elétrica | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 1.5 mm²: 870 cm
EL214 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL215 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL216 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL217 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 153 | 3/4" | Elétrica | 153 | 459
EL218 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 20 | 3/4" | Elétrica | 20 | 80
EL220 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 720 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 360 cm
EL222 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL223 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL224 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL225 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Elétrica | 120 | 360
EL226 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 140 | 3/4" | Elétrica | 140 | 420
EL229 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL230 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 210 | 3/4" | Elétrica | 210 | 1050
EL231 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 241 | 3/4" | Elétrica | 241 | 1205
EL232 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 210.8 | 3/4" | Elétrica | 210.8 | 1054
EL234 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 231 | 3/4" | Elétrica | 231 | 693
EL236 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 241.6 | 3/4" | Elétrica | 241.6 | 724.8
EL237 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 212 | 3/4" | Elétrica | 212 | 636
EL238 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 211 | 3/4" | Elétrica | 211 | 633
EL243 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 330 | 3/4" | Elétrica | 330 | 990
EL246 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 190 | 3/4" | Elétrica | 190 | 570
EL247 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 130 | 3/4" | Elétrica | 130 | 390
EL249 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 480 | 3/4" | Elétrica | 480 | 1440
EL250 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 450 | 3/4" | Elétrica | 450 | 1350
EL251 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 345.5 | 3/4" | Elétrica | 345.5 | 1382
EL252 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 385.5 | 3/4" | Elétrica | 385.5 | 1156.5
EL255 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 480
EL256 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 160 | 3/4" | Elétrica | 160 | 480
EL257 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 363 | 3/4" | Elétrica | 363 | 1089
EL259 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 237 | 3/4" | Elétrica | 237 | 474
EL260 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 275 | 3/4" | Elétrica | 275 | 550
EL261 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 300 | 3/4" | Elétrica | 300 | 600
EL262 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 378 | 3/4" | Elétrica | 378 | 1134
EL263 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 260 | 3/4" | Elétrica | 260
EL265 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 377 | 3/4" | Elétrica | 377 | 754
EL266 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 327 | 3/4" | Elétrica | 327 | 1308
EL267 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 227 | 3/4" | Elétrica | 227 | 681
EL268 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 233 | 3/4" | Elétrica | 233 | 466
EL272 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 220 | 3/4" | Elétrica (ARC) | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 660 cm
EL274 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 142 | 3/4" | Elétrica (ARC) | 142 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 426 cm
EL279 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 40 | 3/4" | Elétrica (ARC) | 40 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 120 cm
EL280 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 419 | 3/4" | Elétrica | 419 | 2095
EL281 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Elétrica (ARC) | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 450 cm
EL282 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 271 | 3/4" | Elétrica | 271 | 1084
EL283 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 262 | 3/4" | Elétrica | 262 | 1572
EL284 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 241 | 3/4" | Elétrica | 241 | 723
EL286 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 70 | 3/4" | Elétrica (ARC) | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 210 cm
EL288 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 93 | 3/4" | Elétrica (ARC) | 93 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - 4 mm²: 279 cm
EL289 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 283 | 3/4" | Elétrica | 283 | 849
EL290 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 234 | 3/4" | Elétrica | 234 | 702
EL291 | PAV 1 | 1.94 | ø3/4" | 0.15 | ø3/4" | 416 | 3/4" | Elétrica | 416 | 1248
CE1 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 40 | 3/4" | Cabeamento | 40 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 40 cm
CE11 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 60 | 3/4" | Cabeamento | 60 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 60 cm
CE13 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 150 | 3/4" | Cabeamento | 150 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 300 cm
CE14 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 60 | 3/4" | Cabeamento | 60 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 180 cm
CE16 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Cabeamento | 110 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 220 cm
CE17 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110 | 3/4" | Cabeamento | 110 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 110 cm
CE18 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Cabeamento | 100 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 200 cm
CE19 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 80 | 3/4" | Cabeamento | 80 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 240 cm
CE2 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 60 | 3/4" | Cabeamento | 60 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 60 cm
CE21 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 100 | 3/4" | Cabeamento | 100 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 100 cm
CE24 | PAV 2 | 3.2 | ø1 1/4" | 0.15 | 1 1/4" | 700 | 1 1/4" | Cabeamento | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 21700 cm
CE25 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 595.42 | 3/4" | Cabeamento | 595.42 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 595.42 cm
CE26 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 885.42 | 3/4" | Cabeamento | 885.42 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 3541.68 cm
CE27 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 705.42 | 3/4" | Cabeamento | 705.42 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 2116.26 cm
CE28 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 590.84 | 3/4" | Cabeamento | 590.84 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 590.84 cm
CE29 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 644.58 | 3/4" | Cabeamento | 644.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 644.58 cm
CE3 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 60 | 3/4" | Cabeamento | 60 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 60 cm
CE30 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 424.58 | 3/4" | Cabeamento | 424.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 1698.32 cm
CE31 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 424.58 | 3/4" | Cabeamento | 424.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 1698.32 cm
CE32 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 424.58 | 3/4" | Cabeamento | 424.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 849.16 cm
CE33 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 424.58 | 3/4" | Cabeamento | 424.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 1698.32 cm
CE34 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 404.58 | 3/4" | Cabeamento | 404.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 809.16 cm
CE35 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 404.58 | 3/4" | Cabeamento | 404.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 809.16 cm
CE37 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 390.08 | 3/4" | Cabeamento | 390.08 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 390.08 cm
CE38 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 340.08 | 3/4" | Cabeamento | 340.08 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 340.08 cm
CE39 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 340.08 | 3/4" | Cabeamento | 340.08 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 340.08 cm
CE4 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 120 | 3/4" | Cabeamento | 120 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 240 cm
CE40 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 320.08 | 3/4" | Cabeamento | 320.08 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 320.08 cm
CE42 | PAV 2 | 2.56 | ø1" | 0.32 | ø1" | 394.5 | 1" | Cabeamento | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto leve - 1": 394.5 cm; Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 1972.5 cm
CE43 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 614.58 | 3/4" | Cabeamento | 614.58 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 614.58 cm
CE5 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 50 | 3/4" | Cabeamento | 50 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 150 cm
CE57 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 110.07 | 3/4" | Cabeamento | 110.07 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 110.07 cm
CE58 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 195.43 | 3/4" | Cabeamento | 195.43 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 195.43 cm
CE59 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 234.57 | 3/4" | Cabeamento | 234.57 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 234.57 cm
CE6 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 60 | 3/4" | Cabeamento | 60 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 60 cm
CE60 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 265.43 | 3/4" | Cabeamento | 265.43 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 265.43 cm
CE61 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 1250 | 3/4" | Cabeamento | 1250
CE63 | PAV 2 | 1.94 | ø3/4" | 0.15 | ø3/4" | 96.8 | 3/4" | Cabeamento | 96.8 | AltoQi_QiBuilder-Itens_Associados - Cabeamento estruturado - metálico - UTP-5e - 24AWG - 4: 193.6 cm
